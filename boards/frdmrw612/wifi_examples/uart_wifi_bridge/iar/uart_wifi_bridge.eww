<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>uart_wifi_bridge</project>
        <configuration>flash_release</configuration>
      </member>
      <member>
        <project>uart_wifi_bridge</project>
        <configuration>flash_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flash_release</name>
      <member>
        <project>uart_wifi_bridge</project>
        <configuration>flash_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flash_debug</name>
      <member>
        <project>uart_wifi_bridge</project>
        <configuration>flash_debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/uart_wifi_bridge.ewp</path>
  </project>
</workspace>
