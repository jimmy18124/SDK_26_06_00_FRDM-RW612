# IAR project fmstr_example_wifi.ewp, settings and files
configuration flash_debug (ARM, debug)
  General.OGChipSelectEditMenu: RW612 NXP RW612
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; USE_RTOS=1; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_RW612ETA2I; RW612_SERIES; OSA_USED; BOOT_HEADER_ENABLE=1; SERIAL_PORT_TYPE_UART=1; WIFI_BOARD_FRDM_RW61X; GENERIC_LIST_LIGHT=1; MFLASH_FILE_BASEADDR=7340032; CONFIG_NXP_WIFI_SOFTAP_SUPPORT=1; PRINTF_FLOAT_ENABLE=1; SO_REUSE=1; SDK_OS_FREE_RTOS
  ICCARM.IExtraOptions: --preinclude ../mcux_config.h --preinclude ../mcuxsdk_version.h --diag_suppress=Pa082,Pa050
  ICCARM.PreInclude: ../app_config.h
  ICCARM.CCIncludePath2: ..; ../../../flash_config; ../../../../../devices/RW612/drivers; ../../../../../CMSIS/Core/Include; ../../../../../CMSIS/Core/Include/m-profile; ../../../../../devices/RW612; ../../../../../devices/RW612/periph; ../../../../../devices/RW612/utilities/debug_console; ../../../../../components/lists; ../../../../../devices/RW612/utilities/str; ../../../../../components/serial_manager; ../../../../../components/uart; ../../../../../components/imu_adapter; ../../../../../components/osa; ../../../../../components/wifi_bt_module/AzureWave/tx_pwr_limits; ../../../../../components/wifi_bt_module/Murata/tx_pwr_limits; ../../../../../components/wifi_bt_module/u-blox/tx_pwr_limits; ../../../../../components/wifi_bt_module/incl; ../../../../../components/els_pkc; ../../../../../components/els_pkc/src/comps/mcuxClBuffer/inc; ../../../../../components/els_pkc/src/comps/mcuxClBuffer/inc/internal; ../../../../../components/els_pkc/src/comps/mcuxClCore/inc; ../../../../../components/els_pkc/src/comps/mcuxClEls/inc; ../../../../../components/els_pkc/src/comps/mcuxClEls/inc/internal; ../../../../../components/els_pkc/src/comps/mcuxClMemory/inc; ../../../../../components/els_pkc/src/comps/mcuxClMemory/inc/internal; ../../../../../components/els_pkc/src/comps/mcuxCsslMemory/inc; ../../../../../components/els_pkc/src/comps/mcuxCsslMemory/inc/internal; ../../../../../components/els_pkc/src/comps/mcuxCsslCPreProcessor/inc; ../../../../../components/els_pkc/src/comps/mcuxCsslDataIntegrity/inc; ../../../../../components/els_pkc/src/comps/mcuxCsslFlowProtection/inc; ../../../../../components/els_pkc/src/comps/mcuxCsslParamIntegrity/inc; ../../../../../components/els_pkc/src/comps/mcuxCsslSecureCounter/inc; ../../../../../components/els_pkc/src/compiler; ../../../../../components/els_pkc/src/platforms/rw61x; ../../../../../components/els_pkc/src/platforms/rw61x/inc; ../../../../../components/els_pkc/includes/platform/rw61x; ../../../../../components/power_manager/core; ../../../../../components/power_manager/devices/RW612; ../../../../../components/flash/mflash; ../../../../../components/flash/mflash/frdmrw612; ../../../../../components/conn_fwloader/include; ../../../../../components/conn_fwloader/fw_bin; ../../../../../components/conn_fwloader/fw_bin/inc/rw61x; ../../../../../components/conn_fwloader/fw_bin/rw61x; ../../../../../components/conn_fwloader/fw_bin/inc/iw610x; ../../../../../components/conn_fwloader/fw_bin/iw610x; ../../../../../components/conn_fwloader/fw_bin/inc/8987; ../../../../../components/conn_fwloader/fw_bin/8987; ../../../../../components/conn_fwloader/fw_bin/inc/IW416; ../../../../../components/conn_fwloader/fw_bin/IW416; ../../../../../components/conn_fwloader/fw_bin/inc/nw61x; ../../../../../components/conn_fwloader/fw_bin/nw61x; ../../../../../components/conn_fwloader/fw_bin/script; ../../../../../middleware/wifi_nxp; ../../../../../middleware/wifi_nxp/incl; ../../../../../middleware/wifi_nxp/incl/port/osa; ../../../../../middleware/wifi_nxp/port/osa; ../../../../../middleware/wifi_nxp/incl/port; ../../../../../middleware/wifi_nxp/incl/wifidriver; ../../../../../middleware/wifi_nxp/wifi_bt_firmware; ../../../../../middleware/wifi_nxp/wifidriver; ../../../../../middleware/wifi_nxp/wifidriver/incl; ../../../../../middleware/wifi_nxp/incl/port/net; ../../../../../middleware/wifi_nxp/incl/port/net/hooks; ../../../../../middleware/wifi_nxp/dhcpd; ../../../../../middleware/wifi_nxp/incl/wlcmgr; ../../../../../middleware/wifi_nxp/wifidriver/wpa_supp_if; ../../../../../middleware/wifi_nxp/wifidriver/wpa_supp_if/incl; ../../../../../middleware/wifi_nxp/certs; ../../../../../middleware/wifi_nxp/firmware_dnld; ../../../../../middleware/wifi_nxp/sdio_nxp_abs; ../../../../../middleware/wifi_nxp/sdio_nxp_abs/incl; ../../../../../middleware/wifi_nxp/port/net; ../../../../../middleware/wifi_nxp/cli; ../../../../../middleware/wifi_nxp/nw_utils; ../../../../../middleware/lwip/port; ../../../../../middleware/lwip/src/include; ../../../../../middleware/lwip/port/sys_arch/dynamic; ../../../../../middleware/freemaster/src/common; ../../../../../middleware/freemaster/src/platforms/gen32le; ../../../../../middleware/freemaster/src/drivers/mcuxsdk/can; ../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial; ../../../../../rtos/freertos/freertos-kernel-upstream/include; ../../../../../rtos/freertos/freertos-kernel/include; ../../../../../rtos/freertos/freertos-kernel-upstream/portable/IAR/ARM_CM33_NTZ/non_secure
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: MCUXPRESSO_SDK; CPU_RW612ETA2I; RW612_SERIES; OSA_USED
  AARM.AUserIncludes: as above
  AARM.PreInclude: ../mcux_config.h
  ILINK.IlinkOutputFile: fmstr_example_wifi.out
  ILINK.IlinkConfigDefines: __heap_size__=0x400; __stack_size__=0x400
  ILINK.IlinkIcfFile: RW610_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_RTOS=1; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_RW612ETA2I; RW612_SERIES; OSA_USED; BOOT_HEADER_ENABLE=1; SERIAL_PORT_TYPE_UART=1; WIFI_BOARD_FRDM_RW61X; GENERIC_LIST_LIGHT=1; MFLASH_FILE_BASEADDR=7340032; CONFIG_NXP_WIFI_SOFTAP_SUPPORT=1; PRINTF_FLOAT_ENABLE=1; SO_REUSE=1; SDK_OS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  group source
    ../: main.c freemaster_cfg.h freemaster_example.h data_example_pmp.h data_html_index.h data_img_file.h data_img_fmstrlogo.h data_img_logo.h example_data.h freemaster_example.c wifi_board.h FreeRTOSConfigBoard.h app_config.h app_config.h network_wifi.h network_wifi.c wifi_config.h lwipopts.h lwippools.h FreeRTOSConfig.h fsl_debug_console_conf.h fsl_os_abstraction_config.h mcux_config.h mcux_config.h mcux_config.h mcuxsdk_version.h
  group board
    ../: board.h board.c clock_config.h clock_config.c pin_mux.h pin_mux.c
  group flash_config
    ../../../flash_config/: flash_config.c flash_config.h
  group drivers
    ../../../../../devices/RW612/drivers/: fsl_clock.c fsl_clock.h fsl_i2s_bridge.c fsl_i2s_bridge.h fsl_inputmux_connections.h fsl_io_mux.h fsl_iped.c fsl_iped.h fsl_memory.h fsl_ocotp.c fsl_ocotp.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_cache.c fsl_cache.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_flexcomm.h fsl_flexcomm.c fsl_usart.h fsl_usart.c fsl_flexspi.c fsl_flexspi.h fsl_gdma.c fsl_gdma.h fsl_imu.h fsl_imu.c fsl_gpio.h fsl_gpio.c fsl_rtc.h fsl_rtc.c
  group drivers/freertos
    ../../../../../devices/RW612/drivers/: fsl_usart_freertos.h fsl_usart_freertos.c
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    ../../../../../CMSIS/Core/Include/m-profile/: cmsis_iccarm_m.h armv8m_mpu.h
  group device
    ../../../../../devices/RW612/: fsl_device_registers.h RW612.h RW612_features.h RW612_COMMON.h system_RW612.c system_RW612.h
  group device/periph
    ../../../../../devices/RW612/periph/: PERI_ACOMP.h PERI_ADC.h PERI_AHB_SECURE_CTRL.h PERI_AON_SOC_CIU.h PERI_APU.h PERI_BG.h PERI_BLEAPU.h PERI_BUCK11.h PERI_BUCK18.h PERI_CACHE64_CTRL.h PERI_CACHE64_POLSEL.h PERI_CAU.h PERI_CDOG.h PERI_CIU1.h PERI_CIU2.h PERI_CLKCTL0.h PERI_CLKCTL1.h PERI_CRC.h PERI_CTIMER.h PERI_DAC.h PERI_DBGMAILBOX.h PERI_DMA.h PERI_DMIC.h PERI_ELS.h PERI_ENET.h PERI_FLEXCOMM.h PERI_FLEXSPI.h PERI_FREQME.h PERI_GDMA.h PERI_GPIO.h PERI_I2C.h PERI_I2S.h PERI_INPUTMUX.h PERI_ITRC.h PERI_LCDIC.h PERI_MCI_IO_MUX.h PERI_MRT.h PERI_OCOTP.h PERI_OSTIMER.h PERI_PINT.h PERI_PKC.h PERI_PMU.h PERI_POWERQUAD.h PERI_PUF.h PERI_RF_SYSCON.h PERI_ROMCP.h PERI_RSTCTL0.h PERI_RSTCTL1.h PERI_RTC.h PERI_SCT.h PERI_SDU_FBR_CARD.h PERI_SDU_FN0_CARD.h PERI_SDU_FN_CARD.h PERI_SENSOR_CTRL.h PERI_SOCCIU.h PERI_SOC_OTP_CTRL.h PERI_SPI.h PERI_SYSCTL0.h PERI_SYSCTL1.h PERI_SYSCTL2.h PERI_SYSPLL_T3.h PERI_SYSPLL_TCPU.h PERI_SYSPLL_TDDR.h PERI_TRNG.h PERI_USART.h PERI_USBC.h PERI_USIM.h PERI_UTICK.h PERI_WLAPU.h PERI_WWDT.h
  group startup/iar
    ../../../../../devices/RW612/iar/: startup_RW612.s
  group utilities
    ../../../../../devices/RW612/utilities/debug_console/: fsl_assert.h fsl_assert.c
  group utilities/str
    ../../../../../devices/RW612/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console
    ../../../../../devices/RW612/utilities/debug_console/: fsl_debug_console.h fsl_debug_console.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/imu_adapter
    ../../../../../components/imu_adapter/: fsl_adapter_imu_common.h fsl_adapter_imu.h fsl_adapter_imu.c
  group component/osa
    ../../../../../components/osa/: fsl_os_abstraction_free_rtos.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction.h
  group component/wifi_bt_module/AzureWave/tx_pwr_limits
    ../../../../../components/wifi_bt_module/AzureWave/tx_pwr_limits/: wlan_txpwrlimit_cfg_WW.h wlan_txpwrlimit_cfg_WW_rw610.h
  group component/wifi_bt_module/Murata/tx_pwr_limits
    ../../../../../components/wifi_bt_module/Murata/tx_pwr_limits/: wlan_txpwrlimit_cfg_murata_1XK_WW.h wlan_txpwrlimit_cfg_murata_1ZM_WW.h wlan_txpwrlimit_cfg_murata_2EL_WW.h wlan_txpwrlimit_cfg_murata_NH.h
  group component/wifi_bt_module/u-blox/tx_pwr_limits
    ../../../../../components/wifi_bt_module/u-blox/tx_pwr_limits/: wlan_txpwrlimit_cfg_jody_w5_WW.h
  group component/wifi_bt_module/incl
    ../../../../../components/wifi_bt_module/incl/: wifi_bt_module_config.h
  group component/els_pkc/src/comps/mcuxClBuffer/src
    ../../../../../components/els_pkc/src/comps/mcuxClBuffer/src/: mcuxClBuffer.c
  group component/els_pkc/src/comps/mcuxClBuffer/inc
    ../../../../../components/els_pkc/src/comps/mcuxClBuffer/inc/: mcuxClBuffer.h mcuxClBuffer_Cfg.h mcuxClBuffer_Constants.h mcuxClBuffer_Impl.h mcuxClBuffer_Pointer.h
  group component/els_pkc/src/comps/mcuxClBuffer/inc/internal
    ../../../../../components/els_pkc/src/comps/mcuxClBuffer/inc/internal/: mcuxClBuffer_Internal.h mcuxClBuffer_Internal_Pointer.h
  group component/els_pkc/src/comps/mcuxClCore/inc
    ../../../../../components/els_pkc/src/comps/mcuxClCore/inc/: mcuxClCore_Examples.h mcuxClCore_FunctionIdentifiers.h mcuxClCore_Macros.h mcuxClCore_Platform.h mcuxClCore_Toolchain.h
  group component/els_pkc/src/comps/mcuxClEls/inc
    ../../../../../components/els_pkc/src/comps/mcuxClEls/inc/: mcuxClEls.h mcuxClEls_Aead.h mcuxClEls_Cipher.h mcuxClEls_Cmac.h mcuxClEls_Crc.h mcuxClEls_Ecc.h mcuxClEls_Hash.h mcuxClEls_Hmac.h mcuxClEls_Kdf.h mcuxClEls_mapping.h mcuxClEls_Rng.h mcuxClEls_Types.h mcuxClEls_KeyManagement.h mcuxClEls_Common.h mcuxClEls_GlitchDetector.h
  group component/els_pkc/src/comps/mcuxClEls/inc/internal
    ../../../../../components/els_pkc/src/comps/mcuxClEls/inc/internal/: mcuxClEls_Internal.h mcuxClEls_Internal_mapping.h mcuxClEls_SfrAccess.h mcuxClEls_Internal_Common.h
  group component/els_pkc/src/comps/mcuxClEls/src
    ../../../../../components/els_pkc/src/comps/mcuxClEls/src/: mcuxClEls_Common.c mcuxClEls_GlitchDetector.c
  group component/els_pkc/src/comps/mcuxClMemory/src
    ../../../../../components/els_pkc/src/comps/mcuxClMemory/src/: mcuxClMemory.c
  group component/els_pkc/src/comps/mcuxClMemory/inc
    ../../../../../components/els_pkc/src/comps/mcuxClMemory/inc/: mcuxClMemory.h mcuxClMemory_Clear.h mcuxClMemory_Constants.h mcuxClMemory_Copy.h mcuxClMemory_Copy_Reversed.h mcuxClMemory_Endianness.h mcuxClMemory_Set.h mcuxClMemory_Types.h mcuxClMemory_Xor.h
  group component/els_pkc/src/comps/mcuxClMemory/inc/internal
    ../../../../../components/els_pkc/src/comps/mcuxClMemory/inc/internal/: mcuxClMemory_Internal.h
  group component/els_pkc/src/comps/mcuxCsslMemory/src
    ../../../../../components/els_pkc/src/comps/mcuxCsslMemory/src/: mcuxCsslMemory_Clear.c mcuxCsslMemory_Compare.c mcuxCsslMemory_Copy.c mcuxCsslMemory_Set.c
  group component/els_pkc/src/comps/mcuxCsslMemory/inc
    ../../../../../components/els_pkc/src/comps/mcuxCsslMemory/inc/: mcuxCsslMemory.h mcuxCsslMemory_Clear.h mcuxCsslMemory_Compare.h mcuxCsslMemory_Constants.h mcuxCsslMemory_Copy.h mcuxCsslMemory_Set.h mcuxCsslMemory_Types.h
  group component/els_pkc/src/comps/mcuxCsslMemory/inc/internal
    ../../../../../components/els_pkc/src/comps/mcuxCsslMemory/inc/internal/: mcuxCsslMemory_Internal_Compare_asm.h mcuxCsslMemory_Internal_Copy_asm.h
  group component/els_pkc/src/comps/mcuxCsslCPreProcessor/inc
    ../../../../../components/els_pkc/src/comps/mcuxCsslCPreProcessor/inc/: mcuxCsslAnalysis.h mcuxCsslCPreProcessor.h
  group component/els_pkc/src/comps/mcuxCsslDataIntegrity/inc
    ../../../../../components/els_pkc/src/comps/mcuxCsslDataIntegrity/inc/: mcuxCsslDataIntegrity.h mcuxCsslDataIntegrity_Cfg.h mcuxCsslDataIntegrity_Impl.h mcuxCsslDataIntegrity_None.h
  group component/els_pkc/src/comps/mcuxCsslFlowProtection/inc
    ../../../../../components/els_pkc/src/comps/mcuxCsslFlowProtection/inc/: mcuxCsslFlowProtection.h mcuxCsslFlowProtection_Cfg.h mcuxCsslFlowProtection_FunctionIdentifiers.h mcuxCsslFlowProtection_Impl.h mcuxCsslFlowProtection_SecureCounter_Common.h mcuxCsslFlowProtection_SecureCounter_Local.h
  group component/els_pkc/src/comps/mcuxCsslParamIntegrity/src
    ../../../../../components/els_pkc/src/comps/mcuxCsslParamIntegrity/src/: mcuxCsslParamIntegrity32.c
  group component/els_pkc/src/comps/mcuxCsslParamIntegrity/inc
    ../../../../../components/els_pkc/src/comps/mcuxCsslParamIntegrity/inc/: mcuxCsslParamIntegrity.h
  group component/els_pkc/src/comps/mcuxCsslSecureCounter/inc
    ../../../../../components/els_pkc/src/comps/mcuxCsslSecureCounter/inc/: mcuxCsslSecureCounter.h mcuxCsslSecureCounter_Cfg.h mcuxCsslSecureCounter_Impl.h mcuxCsslSecureCounter_None.h mcuxCsslSecureCounter_SW_Local.h
  group component/els_pkc/src/compiler
    ../../../../../components/els_pkc/src/compiler/: mcuxClToolchain.h
  group component/els_pkc/src/platforms/rw61x
    ../../../../../components/els_pkc/src/platforms/rw61x/: platform_specific_headers.h mcuxClConfig.h
  group component/els_pkc/src/platforms/rw61x/inc
    ../../../../../components/els_pkc/src/platforms/rw61x/inc/: ip_css_constants.h ip_css_design_configuration.h ip_platform.h
  group component/els_pkc/includes
    ../../../../../components/els_pkc/includes/: mcuxClEls_GlitchDetector.h
  group component/els_pkc/includes/platform/rw61x
    ../../../../../components/els_pkc/includes/platform/rw61x/: mcuxClAeadModes_MemoryConsumption.h mcuxClCipherModes_MemoryConsumption.h mcuxClEcc_MemoryConsumption.h mcuxClHashModes_MemoryConsumption.h mcuxClHash_MemoryConsumption.h mcuxClHmac_MemoryConsumption.h mcuxClKey_MemoryConsumption.h mcuxClMacModes_MemoryConsumption.h mcuxClRandomModes_MemoryConsumption.h mcuxClRsa_MemoryConsumption.h mcuxClSession_MemoryConsumption.h
  group component/power_manager
    ../../../../../components/power_manager/core/: fsl_pm_core.h fsl_pm_core.c fsl_pm_config.h
  group component/devices/RW612
    ../../../../../components/power_manager/devices/RW612/: fsl_pm_device.c fsl_pm_device.h fsl_pm_device_config.h
  group component/conn_fwloader
    ../../../../../components/conn_fwloader/: fsl_loader.c fsl_loader_utils.c nboot_hal.c life_cycle.c readme.txt
  group component/conn_fwloader/include
    ../../../../../components/conn_fwloader/include/: api_tree_root.h fsl_loader.h fsl_loader_utils.h fusemap.h life_cycle.h nboot_rom_api_table.h
  group component/conn_fwloader/fw_bin/rw61x
    ../../../../../components/conn_fwloader/fw_bin/rw61x/: rw61x_sb_wifi_a2.bin rw61x_sb_ble_a2.bin rw61x_sb_ble_15d4_combo_a2.bin rw61x_sb_wifi_a2_compressed.bin rw61x_sb_ble_a2_compressed.bin rw61x_sb_ble_15d4_combo_a2_compressed.bin rw61x_cpu1.c rw61x_cpu2.c
  group component/conn_fwloader/fw_bin/script
    ../../../../../components/conn_fwloader/fw_bin/script/: wlan_gen_fw_incs.py
  group component/conn_fwloader/fw_bin/inc/rw61x
    ../../../../../components/conn_fwloader/fw_bin/inc/rw61x/: rw61x_sb_ble_15d4_combo_a2.bin.inc rw61x_sb_ble_15d4_combo_a2_compressed.bin.inc rw61x_sb_ble_a2.bin.inc rw61x_sb_ble_a2_compressed.bin.inc rw61x_sb_wifi_a2.bin.inc rw61x_sb_wifi_a2_compressed.bin.inc
  group component/conn_fwloader/fw_bin/inc/iw610x
    ../../../../../components/conn_fwloader/fw_bin/inc/iw610x/: sd_iw610.bin.se.inc sd_iw610_compressed.bin.se.inc sduart_iw610.bin.se.inc sduart_iw610_compressed.bin.se.inc sduartspi_iw610.bin.se.inc sduartspi_iw610_compressed.bin.se.inc uart_iw610_bt.bin.se.inc uart_iw610_bt_compressed.bin.se.inc uartspi_iw610.bin.se.inc uartspi_iw610_compressed.bin.se.inc
  group component/conn_fwloader/fw_bin/inc/8987
    ../../../../../components/conn_fwloader/fw_bin/inc/8987/: sd8987_wlan.bin.inc sduart8987_wlan_bt.bin.inc uart8987_bt.bin.inc
  group component/conn_fwloader/fw_bin/inc/IW416
    ../../../../../components/conn_fwloader/fw_bin/inc/IW416/: sdIW416_wlan.bin.inc sduartIW416_wlan_bt.bin.inc uartIW416_bt.bin.inc
  group component/conn_fwloader/fw_bin/inc/nw61x
    ../../../../../components/conn_fwloader/fw_bin/inc/nw61x/: sd_nw61x.bin.se.inc sduart_nw61x.bin.se.inc sduart_nw61x_zb_dual_pan.bin.se.inc uart_nw61x.bin.se.inc uart_nw61x_zb_dual_pan.bin.se.inc
  group component/conn_fwloader/fw_bin/iw610x
    ../../../../../components/conn_fwloader/fw_bin/iw610x/: sduart_iw610_se.h sd_iw610_se.h uart_iw610_se.h iw610_cpu12_se.c iw610_cpu2_se.c iw610_cpu1_se.c
  group component/conn_fwloader/fw_bin/8987
    ../../../../../components/conn_fwloader/fw_bin/8987/: sduart8987_wlan_bt.h sd8987_wlan.h uart8987_bt.h 8987_cpu12.c 8987_cpu1.c 8987_cpu2.c
  group component/conn_fwloader/fw_bin/IW416
    ../../../../../components/conn_fwloader/fw_bin/IW416/: sduartIW416_wlan_bt.h sdIW416_wlan.h uartIW416_bt.h IW416_cpu12.c IW416_cpu1.c IW416_cpu2.c
  group component/conn_fwloader/fw_bin/nw61x
    ../../../../../components/conn_fwloader/fw_bin/nw61x/: sduart_nw61x_se.h sd_nw61x_se.h uart_nw61x_se.h sduart_nw61x_zb_dual_pan_se.h uart_nw61x_zb_dual_pan_se.h nw61x_cpu12_se.c nw61x_cpu1_se.c nw61x_cpu2_se.c
  group flash/mflash
    ../../../../../components/flash/mflash/: mflash_common.h mflash_file.c mflash_file.h
  group flash/mflash/frdmrw612
    ../../../../../components/flash/mflash/frdmrw612/: mflash_drv.c mflash_drv.h
  group wifi
    ../../../../../middleware/wifi_nxp/: ChangeLogKSDK.txt CMakeLists.txt
  group wifi/port/osa
    ../../../../../middleware/wifi_nxp/port/osa/: osa_freertos.h osa_freertos.c osa.c mem_pool.c mem_pool_config.c slist.c stack_simple.c osa_cli.c
  group wifi/port/net
    ../../../../../middleware/wifi_nxp/port/net/: net.c netif_decl.h wifi_netif.c net.c netif_decl.h wifi_netif.c
  group wifi/port/net/hooks
    ../../../../../middleware/wifi_nxp/port/net/hooks/: lwip_default_hooks.c
  group wifi/incl
    ../../../../../middleware/wifi_nxp/incl/: wifi_config_default.h wifi_cal_data_ext.h wm_utils.h wmerrno.h wmlog.h wmtypes.h wifi_cal_data_frdmrw61x_1ant.h wifi_cal_data_rw61x_1ant.h wifi_cal_data_rw61x_1ant_diversity.h wifi_cal_data_rw61x_2ant.h wifi_cal_data_rw61x_3ant_diversity.h wifi_cal_data_override.h dhcp-server.h nxp_wifi.h wmstats.h cli.h cli_utils.h iperf.h wifi_ping.h
  group wifi/incl/port/osa
    ../../../../../middleware/wifi_nxp/incl/port/osa/: osa.h mem_pool.h mem_pool_config.h slist.h stack_simple.h
  group wifi/incl/port/net
    ../../../../../middleware/wifi_nxp/incl/port/net/: wm_net.h wm_net.h wm_net.h
  group wifi/incl/port/net/hooks
    ../../../../../middleware/wifi_nxp/incl/port/net/hooks/: lwip_default_hooks.h
  group wifi/incl/wifidriver
    ../../../../../middleware/wifi_nxp/incl/wifidriver/: wifi-decl.h wifi.h wifi_events.h wifi_nxp.h
  group wifi/incl/wlcmgr
    ../../../../../middleware/wifi_nxp/incl/wlcmgr/: wlan.h wlan_11d.h wlan_test_csi.h wlan_tests.h
  group wifi/wifidriver
    ../../../../../middleware/wifi_nxp/wifidriver/: mlan_11ac.c mlan_11ax.c mlan_11d.c mlan_11h.c mlan_11n.c mlan_11n_aggr.c mlan_11n_rxreorder.c mlan_11v.c mlan_action.c mlan_11k.c mlan_mbo.c mlan_api.c mlan_cfp.c mlan_cmdevt.c mlan_glue.c mlan_init.c mlan_join.c mlan_misc.c mlan_scan.c mlan_shim.c mlan_sta_cmd.c mlan_sta_cmdresp.c mlan_sta_event.c mlan_sta_ioctl.c mlan_sta_rx.c mlan_txrx.c mlan_mgmt_ie.c mlan_wmm.c wifi-debug.c wifi-debug.h wifi-internal.h wifi-mem.c wifi.c wifi_common.h wifi_pwrmgr.c wifi-wps.c wifi-uap.c mlan_uap_ioctl.c mlan_uap_cmdevent.c wifi-imu.c wifi-imu.h
  group wifi/wifidriver/incl
    ../../../../../middleware/wifi_nxp/wifidriver/incl/: mlan_decl.h mlan_ioctl.h type_decls.h mlan.h mlan_11ac.h mlan_11ax.h mlan_11h.h mlan_11n.h mlan_11n_aggr.h mlan_11n_rxreorder.h mlan_11v.h mlan_action.h mlan_11k.h mlan_mbo.h mlan_api.h mlan_fw.h mlan_ieee.h mlan_init.h mlan_join.h mlan_main.h mlan_meas.h mlan_remap_mem_operations.h mlan_uap.h mlan_util.h mlan_mgmt_ie.h mlan_wmm.h
  group wifi/wifidriver/wpa_supp_if
    ../../../../../middleware/wifi_nxp/wifidriver/wpa_supp_if/: wifi_nxp.c rtos_wpa_supp_if.c wifi_nxp_internal.c
  group wifi/wifidriver/wpa_supp_if/incl
    ../../../../../middleware/wifi_nxp/wifidriver/wpa_supp_if/incl/: rtos_wpa_supp_if.h wifi_nxp_internal.h
  group wifi/wifi_bt_firmware
    ../../../../../middleware/wifi_nxp/wifi_bt_firmware/: wlan_bt_fw.h
  group wifi/dhcpd
    ../../../../../middleware/wifi_nxp/dhcpd/: dhcp-bootp.h dhcp-priv.h dhcp-server-main.c dhcp-server.c dns-server.c dns.h dhcp-bootp.h dhcp-priv.h dhcp-server-main.c dhcp-server.c dns-server.c dns.h dhcp-server-cli.c
  group wifi/certs
    ../../../../../middleware/wifi_nxp/certs/: ca-cert.h ca-cert2.h client-cert.h client-cert2.h client-key.h client-key2.h server-cert.h server-key.h dh-param.h
  group wifi/wlcmgr
    ../../../../../middleware/wifi_nxp/wlcmgr/: wlan.c wlan_txpwrlimit_cfg.c wlan_test_csi.c wlan_basic_cli.c wlan_enhanced_tests.c wlan_tests.c wlan_test_mode_tests.c
  group wifi/cli
    ../../../../../middleware/wifi_nxp/cli/: cli_mem.h cli.c cli_mem_simple.c cli_utils.c wifi_shell.h wifi_shell.c
  group wifi/nw_utils
    ../../../../../middleware/wifi_nxp/nw_utils/: wifi_ping.c iperf.c network_cfg.h
  group lwip/port/arch
    ../../../../../middleware/lwip/port/arch/: cc.h perf.h
  group lwip/port/sys_arch/dynamic
    ../../../../../middleware/lwip/port/sys_arch/dynamic/: sys_arch.c
  group lwip/port/sys_arch/dynamic/arch
    ../../../../../middleware/lwip/port/sys_arch/dynamic/arch/: sys_arch.h
  group lwip/src/api
    ../../../../../middleware/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip/src/core
    ../../../../../middleware/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip/src/core/ipv4
    ../../../../../middleware/lwip/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip/src/core/ipv6
    ../../../../../middleware/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group lwip/src/include/compat/posix
    ../../../../../middleware/lwip/src/include/compat/posix/: netdb.h
  group lwip/src/include/compat/posix/arpa
    ../../../../../middleware/lwip/src/include/compat/posix/arpa/: inet.h
  group lwip/src/include/compat/posix/net
    ../../../../../middleware/lwip/src/include/compat/posix/net/: if.h
  group lwip/src/include/compat/posix/sys
    ../../../../../middleware/lwip/src/include/compat/posix/sys/: socket.h
  group lwip/src/include/compat/stdc
    ../../../../../middleware/lwip/src/include/compat/stdc/: errno.h
  group lwip/src/include/lwip
    ../../../../../middleware/lwip/src/include/lwip/: acd.h altcp.h altcp_tcp.h altcp_tls.h api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h if_api.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip6_zone.h ip_addr.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpbase.h tcpip.h timeouts.h udp.h
  group lwip/src/include/lwip/priv
    ../../../../../middleware/lwip/src/include/lwip/priv/: altcp_priv.h api_msg.h memp_priv.h memp_std.h mem_priv.h nd6_priv.h raw_priv.h sockets_priv.h tcpip_priv.h tcp_priv.h
  group lwip/src/include/lwip/prot
    ../../../../../middleware/lwip/src/include/lwip/prot/: acd.h autoip.h dhcp.h dhcp6.h dns.h etharp.h ethernet.h iana.h icmp.h icmp6.h ieee.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group lwip/src/include/lwip/apps
    ../../../../../middleware/lwip/src/include/lwip/apps/: lwiperf.h
  group lwip/src/include/netif
    ../../../../../middleware/lwip/src/include/netif/: bridgeif.h bridgeif_opts.h etharp.h ethernet.h ieee802154.h lowpan6.h lowpan6_ble.h lowpan6_common.h lowpan6_opts.h slipif.h zepif.h
  group lwip/src/include/netif/ppp
    ../../../../../middleware/lwip/src/include/netif/ppp/: ccp.h chap-md5.h chap-new.h chap_ms.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h ppp_impl.h ppp_opts.h upap.h vj.h
  group lwip/src/include/netif/ppp/polarssl
    ../../../../../middleware/lwip/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
  group lwip/src/netif
    ../../../../../middleware/lwip/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group lwip/src/netif/ppp
    ../../../../../middleware/lwip/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group lwip/src/netif/ppp/polarssl
    ../../../../../middleware/lwip/src/netif/ppp/polarssl/: arc4.c des.c md4.c md5.c sha1.c
  group lwip/src/apps/lwiperf
    ../../../../../middleware/lwip/src/apps/lwiperf/: lwiperf.c
  group freemaster/src/common
    ../../../../../middleware/freemaster/src/common/: freemaster.h freemaster_appcmd.c freemaster_defcfg.h freemaster_pipes.c freemaster_private.h freemaster_protocol.c freemaster_protocol.h freemaster_rec.c freemaster_rec.h freemaster_scope.c freemaster_tsa.c freemaster_tsa.h freemaster_ures.c freemaster_ures.h freemaster_utils.c freemaster_utils.h freemaster_can.c freemaster_can.h freemaster_sha.c freemaster_pdbdm.c freemaster_serial.c freemaster_serial.h freemaster_net.c freemaster_net.h
  group freemaster/src/platforms/gen32le
    ../../../../../middleware/freemaster/src/platforms/gen32le/: freemaster_gen32le.h
  group freemaster/src/drivers/mcuxsdk/can
    ../../../../../middleware/freemaster/src/drivers/mcuxsdk/can/: freemaster_flexcan.c freemaster_flexcanfd.h freemaster_flexcanfd.c freemaster_flexcan.h freemaster_mscan.c freemaster_mscan.h freemaster_mcan.c freemaster_mcan.h
  group freemaster/src/drivers/mcuxsdk/serial
    ../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial/: freemaster_serial_uart.c freemaster_serial_uart.h freemaster_serial_lpsci.c freemaster_serial_lpsci.h freemaster_serial_lpuart.c freemaster_serial_lpuart.h freemaster_serial_usart.c freemaster_serial_usart.h freemaster_serial_miniusart.c freemaster_serial_miniusart.h freemaster_serial_usb.c freemaster_serial_usb.h
  group freemaster/src/drivers/mcuxsdk/network
    ../../../../../middleware/freemaster/src/drivers/mcuxsdk/network/: freemaster_net_segger_rtt.c freemaster_net_segger_rtt.h freemaster_net_lwip_udp.c freemaster_net_lwip_udp.h freemaster_net_lwip_tcp.c freemaster_net_lwip_tcp.h
  group freertos/freertos-kernel-upstream
    ../../../../../rtos/freertos/freertos-kernel-upstream/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel-upstream/include
    ../../../../../rtos/freertos/freertos-kernel-upstream/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h
  group freertos/freertos-kernel-upstream/portable
    ../../../../../rtos/freertos/freertos-kernel-upstream/portable/: readme.txt
  group freertos/freertos-kernel-upstream/portable/MemMang
    ../../../../../rtos/freertos/freertos-kernel-upstream/portable/MemMang/: ReadMe.url
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../rtos/freertos/freertos-kernel-upstream/portable/MemMang/: heap_4.c
  group freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure
    ../../../../../rtos/freertos/freertos-kernel-upstream/portable/IAR/ARM_CM33_NTZ/non_secure/: mpu_wrappers_v2_asm.S port.c portasm.h portasm.s portmacro.h portmacrocommon.h
  group freertos/freertos-kernel/include
    ../../../../../rtos/freertos/freertos-kernel/include/: freertos_tasks_c_additions.h
  group doc
    ../: readme.md example_board_readme.md examples_shared_readme.md
