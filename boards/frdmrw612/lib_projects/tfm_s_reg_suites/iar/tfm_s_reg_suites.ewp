# IAR project tfm_s_reg_suites.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: RW612 NXP RW612
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; TFM_SPM_LOG_LEVEL=TFM_SPM_LOG_LEVEL_INFO; TFM_SP_LOG_RAW_ENABLED; TFM_PARTITION_LOG_LEVEL=TFM_PARTITION_LOG_LEVEL_INFO; DAUTH_CHIP_DEFAULT; __SEMIHOST_HARDFAULT_DISABLE; ENABLE_HEAP; CPU_RW612ETA2I; RW612_SERIES; BOOT_HEADER_ENABLE=1; TARGET_CONFIG_HEADER_FILE="config_tfm_target.h"; QCBOR_DISABLE_FLOAT_HW_USE; USEFULBUF_DISABLE_ALL_FLOAT; QCBOR_DISABLE_PREFERRED_FLOAT; TFM_PARTITION_PROTECTED_STORAGE; TFM_PARTITION_TEST_PS; TFM_S_REG_TEST; USE_SP_LOG; MCU_SDK_REGRESSION; TFM_ISOLATION_LEVEL=2; CONFIG_TFM_PARTITION_META; CONFIG_TFM_SPM_BACKEND_IPC=1; TFM_CRYPTO_TEST_ALG_CBC; TFM_CRYPTO_TEST_ALG_CCM; TFM_CRYPTO_TEST_ALG_GCM; TFM_CRYPTO_TEST_ALG_SHA_512; TFM_CRYPTO_TEST_HKDF; TFM_CRYPTO_TEST_ECDH; TFM_CRYPTO_TEST_UNSUPPORTED_ALG; PROJECT_CONFIG_HEADER_FILE="config_profile_large.h"; MBEDTLS_CONFIG_FILE="tfm_mbedcrypto_config_profile_large_client.h"; TFM_PARTITION_INTERNAL_TRUSTED_STORAGE; ATTEST_KEY_BITS=256; T_COSE_DISABLE_MAC0; T_COSE_DISABLE_ES384; T_COSE_DISABLE_ES512; TFM_PARTITION_INITIAL_ATTESTATION; T_COSE_USE_PSA_CRYPTO; TEST_S_ATTESTATION; TFM_PARTITION_CRYPTO; PLATFORM_DEFAULT_CRYPTO_KEYS; MBEDTLS_PSA_CRYPTO_DRIVERS
  ICCARM.CCDiagSuppress: Pa039,Pa082,Pa050,Pa205,Pa084,Pe546,Pe550,Pe940,Pe188,Pe186,Pe177,Pe111,Pe174,Pe128,Pe161,Pe068,Pe223,Pa181
  ICCARM.IExtraOptions: --preinclude ../mcuxsdk_version.h --cmse
  ICCARM.PreInclude: ../mcux_config.h
  ICCARM.CCIncludePath2: ..; ../../../flash_config; ../../../../../devices/RW612/drivers; ../../../../../CMSIS/Core/Include; ../../../../../CMSIS/Core/Include/m-profile; ../../../../../devices/RW612; ../../../../../devices/RW612/periph; ../../../../../components/els_pkc; ../../../../../components/els_pkc/src/comps/mcuxClBuffer/inc; ../../../../../components/els_pkc/src/comps/mcuxClBuffer/inc/internal; ../../../../../components/els_pkc/src/comps/mcuxClCore/inc; ../../../../../components/els_pkc/src/comps/mcuxClEls/inc; ../../../../../components/els_pkc/src/comps/mcuxClEls/inc/internal; ../../../../../components/els_pkc/src/comps/mcuxClMemory/inc; ../../../../../components/els_pkc/src/comps/mcuxClMemory/inc/internal; ../../../../../components/els_pkc/src/comps/mcuxCsslMemory/inc; ../../../../../components/els_pkc/src/comps/mcuxCsslMemory/inc/internal; ../../../../../components/els_pkc/src/comps/mcuxCsslCPreProcessor/inc; ../../../../../components/els_pkc/src/comps/mcuxCsslDataIntegrity/inc; ../../../../../components/els_pkc/src/comps/mcuxCsslFlowProtection/inc; ../../../../../components/els_pkc/src/comps/mcuxCsslParamIntegrity/inc; ../../../../../components/els_pkc/src/comps/mcuxCsslSecureCounter/inc; ../../../../../components/els_pkc/src/compiler; ../../../../../components/els_pkc/src/platforms/rw61x; ../../../../../components/els_pkc/src/platforms/rw61x/inc; ../../../../../components/els_pkc/includes/platform/rw61x; ../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common; ../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/frdmrw612; ../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/frdmrw612/partition; ../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/frdmrw612/Device/Include; ../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/rw61x/platform/include; ../../../../../middleware/tfm/tf-m/platform/ext/driver; ../../../../../middleware/mbedtls3x/include; ../../../../../middleware/tfm/tf-m/platform/include; ../../../../../middleware/tfm/tf-m/interface/include; ../../../../../middleware/tfm/tf-m/interface/include/psa; ../../../../../middleware/tfm/tf-m/interface/include/crypto_keys; ../../../../../middleware/tfm/tf-m/interface/include/psa_manifest; ../../../../../middleware/tfm/qcbor/src; ../../../../../middleware/tfm/qcbor/inc; ../../../../../middleware/tfm/qcbor/inc/qcbor; ../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/suites/ps/secure; ../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/suites/ps/service; ../../../../../middleware/tfm/tf-m/autogenerated/secure_fw/test_services/tfm_ps_test_service/psa_manifest; ../../../../../middleware/tfm/tf-m/autogenerated/secure_fw/test_services/tfm_ps_test_service; ../../../../../middleware/tfm/tf-m/secure_fw/partitions/protected_storage; ../../../../../middleware/tfm/tf-m/secure_fw/include; ../../../../../middleware/tfm/tf-m/config; ../../../../../middleware/tfm/tf-m/secure_fw/spm/core; ../../../../../middleware/tfm/tf-m/secure_fw/spm/include; ../../../../../middleware/tfm/tf-m/lib/fih/inc; ../../../../../middleware/tfm/tf-m/secure_fw/partitions/lib/runtime/include; ../../../../../middleware/tfm/tf-m/secure_fw/partitions/crypto; ../../../../../middleware/tfm/tf-m/secure_fw/partitions/initial_attestation; ../../../../../middleware/tfm/tf-m/secure_fw/partitions/crypto/psa_driver_api; ../../../../../middleware/tfm/tf-m/lib/ext/mbedcrypto/mbedcrypto_config; ../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/Device/Config; ../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/Device/Include; ../../../../../middleware/tfm/tf-m/platform/ext/common; ../../../../../middleware/tfm/tf-m/secure_fw/spm/include/interface; ../../../../../middleware/tfm/tf-m-tests/tests_reg/test/framework; ../../../../../middleware/tfm/tf-m/autogenerated/secure_fw/test_services/tfm_secure_client_service; ../../../../../middleware/tfm/tf-m/autogenerated/secure_fw/test_services/tfm_secure_client_2; ../../../../../middleware/tfm/tf-m/lib/ext/t_cose/inc; ../../../../../middleware/tfm/tf-m/lib/ext/t_cose/src; ../../../../../middleware/tfm/tf-m/config/profile; ../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/suites/its; ../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/suites/its/secure; ../../../../../middleware/tfm/tf-m-tests/lib/log; ../../../../../middleware/tfm/tf-m/secure_fw/spm/include/boot; ../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/suites/attestation/ext/qcbor_util; ../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/suites/attestation/secure; ../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/suites/attestation; ../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/suites/crypto; ../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/suites/crypto/secure; ../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/common_test_services/tfm_secure_client_service; ../../../../../middleware/tfm/tf-m/autogenerated/secure_fw/test_services/tfm_secure_client_service/psa_manifest; ../../../../../middleware/tfm/tf-m/autogenerated/secure_fw/test_services/tfm_secure_client_2/psa_manifest; ../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/common_test_services/tfm_secure_client_2; ../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/suites/spm/ipc/secure
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: CPU_RW612ETA2I; RW612_SERIES
  AARM.AUserIncludes: as above
  AARM.PreInclude: ../mcux_config.h
  ILINK.IlinkOutputFile: psp_arm.out
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; TFM_SPM_LOG_LEVEL=TFM_SPM_LOG_LEVEL_INFO; TFM_SP_LOG_RAW_ENABLED; TFM_PARTITION_LOG_LEVEL=TFM_PARTITION_LOG_LEVEL_INFO; DAUTH_CHIP_DEFAULT; __SEMIHOST_HARDFAULT_DISABLE; ENABLE_HEAP; CPU_RW612ETA2I; RW612_SERIES; BOOT_HEADER_ENABLE=1; TARGET_CONFIG_HEADER_FILE="config_tfm_target.h"; QCBOR_DISABLE_FLOAT_HW_USE; USEFULBUF_DISABLE_ALL_FLOAT; QCBOR_DISABLE_PREFERRED_FLOAT; TFM_PARTITION_PROTECTED_STORAGE; TFM_PARTITION_TEST_PS; TFM_S_REG_TEST; USE_SP_LOG; MCU_SDK_REGRESSION; TFM_ISOLATION_LEVEL=2; CONFIG_TFM_PARTITION_META; CONFIG_TFM_SPM_BACKEND_IPC=1; TFM_CRYPTO_TEST_ALG_CBC; TFM_CRYPTO_TEST_ALG_CCM; TFM_CRYPTO_TEST_ALG_GCM; TFM_CRYPTO_TEST_ALG_SHA_512; TFM_CRYPTO_TEST_HKDF; TFM_CRYPTO_TEST_ECDH; TFM_CRYPTO_TEST_UNSUPPORTED_ALG; PROJECT_CONFIG_HEADER_FILE="config_profile_large.h"; MBEDTLS_CONFIG_FILE="tfm_mbedcrypto_config_profile_large_client.h"; TFM_PARTITION_INTERNAL_TRUSTED_STORAGE; ATTEST_KEY_BITS=256; T_COSE_DISABLE_MAC0; T_COSE_DISABLE_ES384; T_COSE_DISABLE_ES512; TFM_PARTITION_INITIAL_ATTESTATION; T_COSE_USE_PSA_CRYPTO; TEST_S_ATTESTATION; TFM_PARTITION_CRYPTO; PLATFORM_DEFAULT_CRYPTO_KEYS; MBEDTLS_PSA_CRYPTO_DRIVERS
  ICCARM.IExtraOptions: --preinclude ../mcuxsdk_version.h --diag_suppress=Pa082,Pa050 --cmse  --diag_suppress=Pa082,Pa050
  ILINK.IlinkOutputFile: libgeneric.out
  group flash_config
    ../../../flash_config/: flash_config.c flash_config.h
  group drivers
    ../../../../../devices/RW612/drivers/: fsl_clock.c fsl_clock.h fsl_i2s_bridge.c fsl_i2s_bridge.h fsl_inputmux_connections.h fsl_io_mux.h fsl_iped.c fsl_iped.h fsl_memory.h fsl_ocotp.c fsl_ocotp.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_cache.c fsl_cache.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_flexspi.c fsl_flexspi.h fsl_gpio.h fsl_gpio.c
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    ../../../../../CMSIS/Core/Include/m-profile/: cmsis_iccarm_m.h armv8m_mpu.h
  group device
    ../../../../../devices/RW612/: fsl_device_registers.h RW612.h RW612_features.h RW612_COMMON.h system_RW612.c system_RW612.h
  group device/periph
    ../../../../../devices/RW612/periph/: PERI_ACOMP.h PERI_ADC.h PERI_AHB_SECURE_CTRL.h PERI_AON_SOC_CIU.h PERI_APU.h PERI_BG.h PERI_BLEAPU.h PERI_BUCK11.h PERI_BUCK18.h PERI_CACHE64_CTRL.h PERI_CACHE64_POLSEL.h PERI_CAU.h PERI_CDOG.h PERI_CIU1.h PERI_CIU2.h PERI_CLKCTL0.h PERI_CLKCTL1.h PERI_CRC.h PERI_CTIMER.h PERI_DAC.h PERI_DBGMAILBOX.h PERI_DMA.h PERI_DMIC.h PERI_ELS.h PERI_ENET.h PERI_FLEXCOMM.h PERI_FLEXSPI.h PERI_FREQME.h PERI_GDMA.h PERI_GPIO.h PERI_I2C.h PERI_I2S.h PERI_INPUTMUX.h PERI_ITRC.h PERI_LCDIC.h PERI_MCI_IO_MUX.h PERI_MRT.h PERI_OCOTP.h PERI_OSTIMER.h PERI_PINT.h PERI_PKC.h PERI_PMU.h PERI_POWERQUAD.h PERI_PUF.h PERI_RF_SYSCON.h PERI_ROMCP.h PERI_RSTCTL0.h PERI_RSTCTL1.h PERI_RTC.h PERI_SCT.h PERI_SDU_FBR_CARD.h PERI_SDU_FN0_CARD.h PERI_SDU_FN_CARD.h PERI_SENSOR_CTRL.h PERI_SOCCIU.h PERI_SOC_OTP_CTRL.h PERI_SPI.h PERI_SYSCTL0.h PERI_SYSCTL1.h PERI_SYSCTL2.h PERI_SYSPLL_T3.h PERI_SYSPLL_TCPU.h PERI_SYSPLL_TDDR.h PERI_TRNG.h PERI_USART.h PERI_USBC.h PERI_USIM.h PERI_UTICK.h PERI_WLAPU.h PERI_WWDT.h
  group component/els_pkc/src/comps/mcuxClBuffer/src
    ../../../../../components/els_pkc/src/comps/mcuxClBuffer/src/: mcuxClBuffer.c
  group component/els_pkc/src/comps/mcuxClBuffer/inc
    ../../../../../components/els_pkc/src/comps/mcuxClBuffer/inc/: mcuxClBuffer.h mcuxClBuffer_Cfg.h mcuxClBuffer_Constants.h mcuxClBuffer_Impl.h mcuxClBuffer_Pointer.h
  group component/els_pkc/src/comps/mcuxClBuffer/inc/internal
    ../../../../../components/els_pkc/src/comps/mcuxClBuffer/inc/internal/: mcuxClBuffer_Internal.h mcuxClBuffer_Internal_Pointer.h
  group component/els_pkc/src/comps/mcuxClCore/inc
    ../../../../../components/els_pkc/src/comps/mcuxClCore/inc/: mcuxClCore_Examples.h mcuxClCore_FunctionIdentifiers.h mcuxClCore_Macros.h mcuxClCore_Platform.h mcuxClCore_Toolchain.h
  group component/els_pkc/src/comps/mcuxClEls/inc
    ../../../../../components/els_pkc/src/comps/mcuxClEls/inc/: mcuxClEls.h mcuxClEls_Aead.h mcuxClEls_Cipher.h mcuxClEls_Cmac.h mcuxClEls_Crc.h mcuxClEls_Ecc.h mcuxClEls_Hash.h mcuxClEls_Hmac.h mcuxClEls_Kdf.h mcuxClEls_mapping.h mcuxClEls_Rng.h mcuxClEls_Types.h mcuxClEls_KeyManagement.h mcuxClEls_Common.h mcuxClEls_GlitchDetector.h
  group component/els_pkc/src/comps/mcuxClEls/inc/internal
    ../../../../../components/els_pkc/src/comps/mcuxClEls/inc/internal/: mcuxClEls_Internal.h mcuxClEls_Internal_mapping.h mcuxClEls_SfrAccess.h mcuxClEls_Internal_Common.h
  group component/els_pkc/src/comps/mcuxClEls/src
    ../../../../../components/els_pkc/src/comps/mcuxClEls/src/: mcuxClEls_Common.c mcuxClEls_GlitchDetector.c
  group component/els_pkc/src/comps/mcuxClMemory/src
    ../../../../../components/els_pkc/src/comps/mcuxClMemory/src/: mcuxClMemory.c
  group component/els_pkc/src/comps/mcuxClMemory/inc
    ../../../../../components/els_pkc/src/comps/mcuxClMemory/inc/: mcuxClMemory.h mcuxClMemory_Clear.h mcuxClMemory_Constants.h mcuxClMemory_Copy.h mcuxClMemory_Copy_Reversed.h mcuxClMemory_Endianness.h mcuxClMemory_Set.h mcuxClMemory_Types.h mcuxClMemory_Xor.h
  group component/els_pkc/src/comps/mcuxClMemory/inc/internal
    ../../../../../components/els_pkc/src/comps/mcuxClMemory/inc/internal/: mcuxClMemory_Internal.h
  group component/els_pkc/src/comps/mcuxCsslMemory/src
    ../../../../../components/els_pkc/src/comps/mcuxCsslMemory/src/: mcuxCsslMemory_Clear.c mcuxCsslMemory_Compare.c mcuxCsslMemory_Copy.c mcuxCsslMemory_Set.c
  group component/els_pkc/src/comps/mcuxCsslMemory/inc
    ../../../../../components/els_pkc/src/comps/mcuxCsslMemory/inc/: mcuxCsslMemory.h mcuxCsslMemory_Clear.h mcuxCsslMemory_Compare.h mcuxCsslMemory_Constants.h mcuxCsslMemory_Copy.h mcuxCsslMemory_Set.h mcuxCsslMemory_Types.h
  group component/els_pkc/src/comps/mcuxCsslMemory/inc/internal
    ../../../../../components/els_pkc/src/comps/mcuxCsslMemory/inc/internal/: mcuxCsslMemory_Internal_Compare_asm.h mcuxCsslMemory_Internal_Copy_asm.h
  group component/els_pkc/src/comps/mcuxCsslCPreProcessor/inc
    ../../../../../components/els_pkc/src/comps/mcuxCsslCPreProcessor/inc/: mcuxCsslAnalysis.h mcuxCsslCPreProcessor.h
  group component/els_pkc/src/comps/mcuxCsslDataIntegrity/inc
    ../../../../../components/els_pkc/src/comps/mcuxCsslDataIntegrity/inc/: mcuxCsslDataIntegrity.h mcuxCsslDataIntegrity_Cfg.h mcuxCsslDataIntegrity_Impl.h mcuxCsslDataIntegrity_None.h
  group component/els_pkc/src/comps/mcuxCsslFlowProtection/inc
    ../../../../../components/els_pkc/src/comps/mcuxCsslFlowProtection/inc/: mcuxCsslFlowProtection.h mcuxCsslFlowProtection_Cfg.h mcuxCsslFlowProtection_FunctionIdentifiers.h mcuxCsslFlowProtection_Impl.h mcuxCsslFlowProtection_SecureCounter_Common.h mcuxCsslFlowProtection_SecureCounter_Local.h
  group component/els_pkc/src/comps/mcuxCsslParamIntegrity/src
    ../../../../../components/els_pkc/src/comps/mcuxCsslParamIntegrity/src/: mcuxCsslParamIntegrity32.c
  group component/els_pkc/src/comps/mcuxCsslParamIntegrity/inc
    ../../../../../components/els_pkc/src/comps/mcuxCsslParamIntegrity/inc/: mcuxCsslParamIntegrity.h
  group component/els_pkc/src/comps/mcuxCsslSecureCounter/inc
    ../../../../../components/els_pkc/src/comps/mcuxCsslSecureCounter/inc/: mcuxCsslSecureCounter.h mcuxCsslSecureCounter_Cfg.h mcuxCsslSecureCounter_Impl.h mcuxCsslSecureCounter_None.h mcuxCsslSecureCounter_SW_Local.h
  group component/els_pkc/src/compiler
    ../../../../../components/els_pkc/src/compiler/: mcuxClToolchain.h
  group component/els_pkc/src/platforms/rw61x
    ../../../../../components/els_pkc/src/platforms/rw61x/: platform_specific_headers.h mcuxClConfig.h
  group component/els_pkc/src/platforms/rw61x/inc
    ../../../../../components/els_pkc/src/platforms/rw61x/inc/: ip_css_constants.h ip_css_design_configuration.h ip_platform.h
  group component/els_pkc/includes
    ../../../../../components/els_pkc/includes/: mcuxClEls_GlitchDetector.h
  group component/els_pkc/includes/platform/rw61x
    ../../../../../components/els_pkc/includes/platform/rw61x/: mcuxClAeadModes_MemoryConsumption.h mcuxClCipherModes_MemoryConsumption.h mcuxClEcc_MemoryConsumption.h mcuxClHashModes_MemoryConsumption.h mcuxClHash_MemoryConsumption.h mcuxClHmac_MemoryConsumption.h mcuxClKey_MemoryConsumption.h mcuxClMacModes_MemoryConsumption.h mcuxClRandomModes_MemoryConsumption.h mcuxClRsa_MemoryConsumption.h mcuxClSession_MemoryConsumption.h
  group tf-m/platform/ext/target/nxp/common
    ../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/: target_cfg_common.h
  group tf-m/platform/ext/target/nxp/common/Device/Config
    ../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/Device/Config/: device_cfg.h
  group tf-m/platform/ext/target/nxp/common/Device/Include
    ../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/Device/Include/: cmsis.h device_definition.h platform_description.h platform_irq.h platform_regs.h
  group tf-m/platform/ext/target/nxp/frdmrw612
    ../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/frdmrw612/: platform_psa_hw_accel.h config_tfm_target.h target_cfg.h tfm_peripherals_def.h
  group tf-m/platform/ext/target/nxp/frdmrw612/Device/Include
    ../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/frdmrw612/Device/Include/: platform_base_address.h
  group tf-m/platform/ext/target/nxp/frdmrw612/partition
    ../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/frdmrw612/partition/: region_defs.h flash_layout.h
  group tf-m/platform/ext/target/nxp/rw61x/platform/include
    ../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/rw61x/platform/include/: platform_nv_counters_ids.h
  group tf-m/platform/ext/driver
    ../../../../../middleware/tfm/tf-m/platform/ext/driver/: Driver_Common.h Driver_Flash.h Driver_MPC.h Driver_PPC.h Driver_USART.h
  group tf-m/platform/ext/common
    ../../../../../middleware/tfm/tf-m/platform/ext/common/: tfm_hal_sp_logdev.h tfm_hal_spm_logdev.h uart_stdout.h
  group tf-m/platform/include
    ../../../../../middleware/tfm/tf-m/platform/include/: tfm_hal_device_header.h region.h cmsis_override.h
  group tf-m/autogenerated/secure_fw/test_services/tfm_ps_test_service/auto_generated
    ../../../../../middleware/tfm/tf-m/autogenerated/secure_fw/test_services/tfm_ps_test_service/auto_generated/: intermedia_tfm_ps_test_service.c
  group tf-m/autogenerated/secure_fw/test_services/tfm_ps_test_service/psa_manifest
    ../../../../../middleware/tfm/tf-m/autogenerated/secure_fw/test_services/tfm_ps_test_service/psa_manifest/: tfm_ps_test_service.h
  group tf-m/autogenerated/secure_fw/test_services/tfm_secure_client_service/psa_manifest
    ../../../../../middleware/tfm/tf-m/autogenerated/secure_fw/test_services/tfm_secure_client_service/psa_manifest/: tfm_secure_client_service.h tfm_secure_client_service.h
  group tf-m/autogenerated/secure_fw/test_services/tfm_secure_client_2/psa_manifest
    ../../../../../middleware/tfm/tf-m/autogenerated/secure_fw/test_services/tfm_secure_client_2/psa_manifest/: tfm_secure_client_2.h
  group tf-m/secure_fw/partitions/protected_storage
    ../../../../../middleware/tfm/tf-m/secure_fw/partitions/protected_storage/: ps_object_system.h
  group tf-m/secure_fw/partitions/lib/runtime/include
    ../../../../../middleware/tfm/tf-m/secure_fw/partitions/lib/runtime/include/: service_api.h tfm_sp_log.h
  group tf-m/secure_fw/partitions/initial_attestation
    ../../../../../middleware/tfm/tf-m/secure_fw/partitions/initial_attestation/: attest.h attest_token.h attest.h
  group tf-m/secure_fw/include
    ../../../../../middleware/tfm/tf-m/secure_fw/include/: config_tfm.h
  group tf-m/secure_fw/spm/core
    ../../../../../middleware/tfm/tf-m/secure_fw/spm/core/: spm.h
  group tf-m/secure_fw/spm/include
    ../../../../../middleware/tfm/tf-m/secure_fw/spm/include/: config_spm.h tfm_arch.h tfm_arch_v8m.h utilities.h
  group tf-m/secure_fw/spm/include/interface
    ../../../../../middleware/tfm/tf-m/secure_fw/spm/include/interface/: runtime_defs.h svc_num.h
  group tf-m/secure_fw/spm/include/boot
    ../../../../../middleware/tfm/tf-m/secure_fw/spm/include/boot/: tfm_boot_status.h tfm_boot_status.h
  group tf-m/config
    ../../../../../middleware/tfm/tf-m/config/: config_base.h
  group tf-m/lib/fih/inc
    ../../../../../middleware/tfm/tf-m/lib/fih/inc/: fih.h
  group tf-m/lib/ext/t_cose/src
    ../../../../../middleware/tfm/tf-m/lib/ext/t_cose/src/: t_cose_crypto.h t_cose_parameters.h t_cose_standard_constants.h t_cose_util.h t_cose_sign1_verify.c
  group tf-m/lib/ext/t_cose/inc
    ../../../../../middleware/tfm/tf-m/lib/ext/t_cose/inc/: t_cose_common.h q_useful_buf.h t_cose_sign1_sign.h t_cose_sign1_verify.h
  group mbedtls3x/include/psa
    ../../../../../middleware/mbedtls3x/include/psa/: crypto_config.h
  group tfm/tf-m/platform/include
    ../../../../../middleware/tfm/tf-m/platform/include/: boot_hal.h cmsis_override.h exception_info.h fatal_error.h mbedtls_entropy_nv_seed_config.h region.h tfm_attest_hal.h tfm_hal_defs.h tfm_hal_device_header.h tfm_hal_interrupt.h tfm_hal_isolation.h tfm_hal_its.h tfm_hal_its_encryption.h tfm_hal_mailbox.h tfm_hal_multi_core.h tfm_hal_platform.h tfm_hal_ps.h tfm_plat_boot_seed.h tfm_plat_config.h tfm_plat_crypto_keys.h tfm_plat_crypto_nv_seed.h tfm_plat_defs.h tfm_plat_device_id.h tfm_plat_ns.h tfm_plat_nv_counters.h tfm_plat_otp.h tfm_plat_provisioning.h tfm_plat_rotpk.h tfm_plat_test.h tfm_platform_system.h
  group tfm/tf-m/interface/include
    ../../../../../middleware/tfm/tf-m/interface/include/: config_impl.h tfm_attest_defs.h tfm_attest_iat_defs.h tfm_crypto_defs.h tfm_fwu_defs.h tfm_its_defs.h tfm_ns_client_ext.h tfm_ns_interface.h tfm_platform_api.h tfm_ps_defs.h tfm_psa_call_pack.h tfm_veneers.h
  group tfm/tf-m/interface/include/psa_manifest
    ../../../../../middleware/tfm/tf-m/interface/include/psa_manifest/: sid.h pid.h
  group tfm/tf-m/interface/include/psa
    ../../../../../middleware/tfm/tf-m/interface/include/psa/: build_info.h client.h crypto.h crypto_adjust_auto_enabled.h crypto_adjust_config_dependencies.h crypto_adjust_config_key_pair_types.h crypto_adjust_config_synonyms.h crypto_builtin_composites.h crypto_builtin_key_derivation.h crypto_builtin_primitives.h crypto_compat.h crypto_driver_common.h crypto_driver_contexts_composites.h crypto_driver_contexts_key_derivation.h crypto_driver_contexts_primitives.h crypto_extra.h crypto_legacy.h crypto_platform.h crypto_se_driver.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h error.h framework_feature.h initial_attestation.h internal_trusted_storage.h lifecycle.h protected_storage.h service.h storage_common.h update.h
  group tfm/tf-m/interface/include/mbedtls
    ../../../../../middleware/tfm/tf-m/interface/include/mbedtls/: aes.h aria.h asn1.h asn1write.h base64.h bignum.h block_cipher.h build_info.h camellia.h ccm.h chacha20.h chachapoly.h check_config.h cipher.h cmac.h compat-2.x.h config_adjust_legacy_crypto.h config_adjust_legacy_from_psa.h config_adjust_psa_from_legacy.h config_adjust_psa_superset_legacy.h config_adjust_ssl.h config_adjust_x509.h config_psa.h constant_time.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h entropy.h error.h gcm.h hkdf.h hmac_drbg.h lms.h md.h md5.h memory_buffer_alloc.h net_sockets.h nist_kw.h oid.h pem.h pk.h pkcs12.h pkcs5.h pkcs7.h platform.h platform_time.h platform_util.h poly1305.h private_access.h psa_util.h ripemd160.h rsa.h sha1.h sha256.h sha3.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h
  group tfm/tf-m/interface/include/crypto_keys
    ../../../../../middleware/tfm/tf-m/interface/include/crypto_keys/: tfm_builtin_key_ids.h
  group tfm/tf-m/lib/ext/mbedcrypto/mbedcrypto_config
    ../../../../../middleware/tfm/tf-m/lib/ext/mbedcrypto/mbedcrypto_config/: tfm_mbedcrypto_config_profile_large_client.h
  group tfm/tf-m/config/profile
    ../../../../../middleware/tfm/tf-m/config/profile/: config_profile_large.h
  group qcbor/src
    ../../../../../middleware/tfm/qcbor/src/: ieee754.c ieee754.h qcbor_decode.c qcbor_encode.c UsefulBuf.c
  group qcbor/inc/qcbor
    ../../../../../middleware/tfm/qcbor/inc/qcbor/: qcbor.h qcbor_common.h qcbor_decode.h qcbor_encode.h qcbor_private.h qcbor_spiffy_decode.h UsefulBuf.h qcbor.h UsefulBuf.h
  group tf-m-tests/tests_reg/test/secure_fw/suites/ps/secure
    ../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/suites/ps/secure/: psa_ps_s_interface_testsuite.c psa_ps_s_reliability_testsuite.c s_test_helpers.h ps_tests.h
  group tf-m-tests/tests_reg/test/secure_fw/suites/ps/service
    ../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/suites/ps/service/: tfm_ps_test_service.c tfm_ps_test_service_api.c tfm_ps_test_service_api.h
  group tf-m-tests/tests_reg/test/secure_fw/suites/its
    ../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/suites/its/: its_tests_common.c its_tests_common.h
  group tf-m-tests/tests_reg/test/secure_fw/suites/its/secure
    ../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/suites/its/secure/: its_s_tests.h psa_its_s_interface_testsuite.c psa_its_s_reliability_testsuite.c
  group tf-m-tests/tests_reg/test/secure_fw/suites/attestation
    ../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/suites/attestation/: attest_token_decode_asymmetric.c attest_token_decode.h attest_token_decode_common.c attest_token_test.c attest_token_test.h attest_token_test_values.h attest_tests_common.h
  group tf-m-tests/tests_reg/test/secure_fw/suites/attestation/secure
    ../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/suites/attestation/secure/: attest_asymmetric_s_interface_testsuite.c attest_s_tests.h
  group tf-m-tests/tests_reg/test/secure_fw/suites/attestation/ext/qcbor_util
    ../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/suites/attestation/ext/qcbor_util/: qcbor_util.c qcbor_util.h
  group tf-m-tests/tests_reg/test/secure_fw/suites/crypto
    ../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/suites/crypto/: crypto_tests_common.c crypto_tests_common.h crypto_tests_check_config.h
  group tf-m-tests/tests_reg/test/secure_fw/suites/crypto/secure
    ../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/suites/crypto/secure/: crypto_s_tests.h crypto_sec_interface_testsuite.c
  group tf-m-tests/tests_reg/test/secure_fw/suites/spm/ipc/secure
    ../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/suites/spm/ipc/secure/: ipc_s_tests.h
  group tf-m-tests/tests_reg/test/secure_fw/common_test_services/tfm_secure_client_service
    ../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/common_test_services/tfm_secure_client_service/: tfm_secure_client_service.h tfm_secure_client_service.h
  group tf-m-tests/tests_reg/test/secure_fw/common_test_services/tfm_secure_client_2
    ../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/common_test_services/tfm_secure_client_2/: tfm_secure_client_2_api.h tfm_secure_client_2.c tfm_secure_client_2_api.c
  group tf-m-tests/tests_reg/test/framework
    ../../../../../middleware/tfm/tf-m-tests/tests_reg/test/framework/: test_framework.h test_framework_error_codes.h test_framework_helpers.h test_log.h test_framework.h
  group tf-m-tests/lib/log
    ../../../../../middleware/tfm/tf-m-tests/lib/log/: tfm_log.h tfm_log_raw.c tfm_log_raw.h tfm_log_raw.h tfm_log_raw.c
  group source
    ../: mcux_config.h mcux_config.h mcux_config.h mcuxsdk_version.h
