<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/tfm_s_crypto_clients.ewp</path>
  </project>
</workspace>
