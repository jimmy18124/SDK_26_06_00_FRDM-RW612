<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>el2go_import_blob_s</project>
        <configuration>debug</configuration>
      </member>
      <member>
        <project>el2go_import_blob_s</project>
        <configuration>release</configuration>
      </member>
      <member>
        <project>el2go_import_blob_ns</project>
        <configuration>debug</configuration>
      </member>
      <member>
        <project>tfm_s_crypto_clients</project>
        <configuration>debug</configuration>
      </member>
      <member>
        <project>el2go_import_blob_ns</project>
        <configuration>release</configuration>
      </member>
      <member>
        <project>tfm_s_crypto_clients</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>el2go_import_blob_s</project>
        <configuration>debug</configuration>
      </member>
      <member>
        <project>el2go_import_blob_ns</project>
        <configuration>debug</configuration>
      </member>
      <member>
        <project>tfm_s_crypto_clients</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>el2go_import_blob_s</project>
        <configuration>release</configuration>
      </member>
      <member>
        <project>el2go_import_blob_ns</project>
        <configuration>release</configuration>
      </member>
      <member>
        <project>tfm_s_crypto_clients</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/el2go_import_blob_s.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/../../el2go_import_blob_ns/iar/el2go_import_blob_ns.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/../../../../lib_projects/tfm_s_crypto_clients/iar/tfm_s_crypto_clients.ewp</path>
  </project>
</workspace>
