# IAR project el2go_import_blob_ns.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: RW612 NXP RW612
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; USE_OCOTP_DRIVER_IN_LOAD_SERVICE; MBEDTLS_USER_CONFIG_FILE="el2go_mbedtls_user_config_bare_metal.h"; PRINTF_ADVANCED_ENABLE=1; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_RW612ETA2I; RW612_SERIES; BOOT_HEADER_ENABLE=1; MBEDTLS_CONFIG_FILE="mcux_mbedtls_config.h"; TARGET_CONFIG_HEADER_FILE="config_tfm_target.h"; TFM_ISOLATION_LEVEL=2; CONFIG_TFM_PARTITION_META; CONFIG_TFM_SPM_BACKEND_IPC=1; PROJECT_CONFIG_HEADER_FILE="config_profile_large.h"; CONFIG_TFM_FLOAT_ABI=2; CONFIG_TFM_ENABLE_CP10CP11; CONFIG_TFM_LAZY_STACKING; __DOMAIN_NS=1; DOMAIN_NS=1; CONFIG_TFM_USE_TRUSTZONE; ATTEST_TOKEN_PROFILE_PSA_IOT_1; PLATFORM_DEFAULT_CRYPTO_KEYS; PS_ENCRYPTION
  ICCARM.IExtraOptions: --preinclude ../mcuxsdk_version.h --diag_suppress=Pa084,Pe188,Pe546  --diag_suppress=Pa082,Pa050  --diag_suppress=Pe111,Pe546,Pe550,Pa217 --diag_suppress=Pa082,Pa050  --diag_suppress=Pe111,Pe546,Pe550,Pa217
  ICCARM.PreInclude: ../mcux_config.h
  ICCARM.CCIncludePath2: ..; ../../../../flash_config; ../../../../../../devices/RW612/drivers; ../../../../../../CMSIS/Core/Include; ../../../../../../CMSIS/Core/Include/m-profile; ../../../../../../devices/RW612; ../../../../../../devices/RW612/periph; ../../../../../../devices/RW612/utilities/debug_console_lite; ../../../../../../devices/RW612/utilities/str; ../../../../../../components/uart; ../../../../../../components/els_pkc; ../../../../../../components/els_pkc/src/comps/mcuxClBuffer/inc; ../../../../../../components/els_pkc/src/comps/mcuxClBuffer/inc/internal; ../../../../../../components/els_pkc/src/comps/mcuxClCore/inc; ../../../../../../components/els_pkc/src/comps/mcuxClEls/inc; ../../../../../../components/els_pkc/src/comps/mcuxClEls/inc/internal; ../../../../../../components/els_pkc/src/comps/mcuxClMemory/inc; ../../../../../../components/els_pkc/src/comps/mcuxClMemory/inc/internal; ../../../../../../components/els_pkc/src/comps/mcuxCsslMemory/inc; ../../../../../../components/els_pkc/src/comps/mcuxCsslMemory/inc/internal; ../../../../../../components/els_pkc/src/comps/mcuxCsslCPreProcessor/inc; ../../../../../../components/els_pkc/src/comps/mcuxCsslDataIntegrity/inc; ../../../../../../components/els_pkc/src/comps/mcuxCsslFlowProtection/inc; ../../../../../../components/els_pkc/src/comps/mcuxCsslParamIntegrity/inc; ../../../../../../components/els_pkc/src/comps/mcuxCsslSecureCounter/inc; ../../../../../../components/els_pkc/src/compiler; ../../../../../../components/els_pkc/src/platforms/rw61x; ../../../../../../components/els_pkc/src/platforms/rw61x/inc; ../../../../../../components/els_pkc/includes/platform/rw61x; ../../../../../../components/conn_fwloader/include; ../../../../../../middleware/mbedtls3x/include; ../../../../../../middleware/mbedtls3x/include/mbedtls; ../../../../../../middleware/mbedtls3x/library; ../../../../../../middleware/mbedtls3x/port; ../../../../../../middleware/mbedtls3x/port/tfm; ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common; ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/frdmrw612; ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/frdmrw612/partition; ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/frdmrw612/Device/Include; ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/rw61x/platform/include; ../../../../../../middleware/tfm/tf-m/platform/ext/driver; ../../../../../../middleware/tfm/tf-m/platform/include; ../../../../../../middleware/tfm/tf-m/interface/include; ../../../../../../middleware/tfm/tf-m/interface/include/psa; ../../../../../../middleware/tfm/tf-m/interface/include/crypto_keys; ../../../../../../middleware/tfm/tf-m/interface/include/psa_manifest; ../../../../../../middleware/tfm/tf-m/config/profile; ../../../../../../middleware/tfm/tf-m/lib/ext/mbedcrypto/mbedcrypto_config; ../../../../../../middleware/tfm/tf-m/platform/ext; ../../../../../../middleware/tfm/tf-m/platform/ext/common; ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/Device/Config; ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/Device/Include; ../../../../../../middleware/tfm/tf-m/interface/include/os_wrapper; ../../../../../../middleware/tfm/tf-m/secure_fw/spm/include; ../../../../../../middleware/tfm/tf-m/secure_fw/include; ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/crypto; ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/initial_attestation; ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/internal_trusted_storage; ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/protected_storage; ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/platform; ../../../../../../middleware/tfm/tf-m/config; ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/rw61x/partitions/loader_service; ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/rw61x/partitions/loader_service/interface/include; ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/rw61x/plat_iak_pk
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: MCUXPRESSO_SDK; CPU_RW612ETA2I; RW612_SERIES
  AARM.AUserIncludes: as above
  AARM.PreInclude: ../mcux_config.h
  ILINK.IlinkOutputFile: el2go_import_blob_ns.out
  ILINK.IlinkIcfFile: ../../../../../../middleware/tfm/tf-m/platform/ext/common/iar/tfm_common_ns_pre.icf
  ILINK.IlinkAdditionalLibs: ../../el2go_import_blob_s/iar/debug/el2go_import_blob_s_import_lib.o
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_OCOTP_DRIVER_IN_LOAD_SERVICE; MBEDTLS_USER_CONFIG_FILE="el2go_mbedtls_user_config_bare_metal.h"; PRINTF_ADVANCED_ENABLE=1; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_RW612ETA2I; RW612_SERIES; BOOT_HEADER_ENABLE=1; MBEDTLS_CONFIG_FILE="mcux_mbedtls_config.h"; TARGET_CONFIG_HEADER_FILE="config_tfm_target.h"; TFM_ISOLATION_LEVEL=2; CONFIG_TFM_PARTITION_META; CONFIG_TFM_SPM_BACKEND_IPC=1; PROJECT_CONFIG_HEADER_FILE="config_profile_large.h"; CONFIG_TFM_FLOAT_ABI=2; CONFIG_TFM_ENABLE_CP10CP11; CONFIG_TFM_LAZY_STACKING; __DOMAIN_NS=1; DOMAIN_NS=1; CONFIG_TFM_USE_TRUSTZONE; ATTEST_TOKEN_PROFILE_PSA_IOT_1; PLATFORM_DEFAULT_CRYPTO_KEYS; PS_ENCRYPTION
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../el2go_import_blob_s/iar/release/el2go_import_blob_s_import_lib.o
  group source
    ../: el2go_mbedtls_user_config_bare_metal.h el2go_import_blob.h el2go_psa_import.h el2go_import_blob.c el2go_psa_import.c mcux_config.h mcux_config.h mcux_config.h mcuxsdk_version.h
  group board
    ../: board.h board.c clock_config.h clock_config.c pin_mux.h pin_mux.c hardware_init.c app.h
  group flash_config
    ../../../../flash_config/: flash_config.c flash_config.h
  group drivers
    ../../../../../../devices/RW612/drivers/: fsl_clock.c fsl_clock.h fsl_i2s_bridge.c fsl_i2s_bridge.h fsl_inputmux_connections.h fsl_io_mux.h fsl_iped.c fsl_iped.h fsl_memory.h fsl_ocotp.c fsl_ocotp.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_cache.c fsl_cache.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_flexcomm.h fsl_flexcomm.c fsl_usart.h fsl_usart.c fsl_flexspi.c fsl_flexspi.h fsl_gpio.h fsl_gpio.c
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    ../../../../../../CMSIS/Core/Include/m-profile/: cmsis_iccarm_m.h armv8m_mpu.h
  group device
    ../../../../../../devices/RW612/: fsl_device_registers.h RW612.h RW612_features.h RW612_COMMON.h system_RW612.c system_RW612.h
  group device/periph
    ../../../../../../devices/RW612/periph/: PERI_ACOMP.h PERI_ADC.h PERI_AHB_SECURE_CTRL.h PERI_AON_SOC_CIU.h PERI_APU.h PERI_BG.h PERI_BLEAPU.h PERI_BUCK11.h PERI_BUCK18.h PERI_CACHE64_CTRL.h PERI_CACHE64_POLSEL.h PERI_CAU.h PERI_CDOG.h PERI_CIU1.h PERI_CIU2.h PERI_CLKCTL0.h PERI_CLKCTL1.h PERI_CRC.h PERI_CTIMER.h PERI_DAC.h PERI_DBGMAILBOX.h PERI_DMA.h PERI_DMIC.h PERI_ELS.h PERI_ENET.h PERI_FLEXCOMM.h PERI_FLEXSPI.h PERI_FREQME.h PERI_GDMA.h PERI_GPIO.h PERI_I2C.h PERI_I2S.h PERI_INPUTMUX.h PERI_ITRC.h PERI_LCDIC.h PERI_MCI_IO_MUX.h PERI_MRT.h PERI_OCOTP.h PERI_OSTIMER.h PERI_PINT.h PERI_PKC.h PERI_PMU.h PERI_POWERQUAD.h PERI_PUF.h PERI_RF_SYSCON.h PERI_ROMCP.h PERI_RSTCTL0.h PERI_RSTCTL1.h PERI_RTC.h PERI_SCT.h PERI_SDU_FBR_CARD.h PERI_SDU_FN0_CARD.h PERI_SDU_FN_CARD.h PERI_SENSOR_CTRL.h PERI_SOCCIU.h PERI_SOC_OTP_CTRL.h PERI_SPI.h PERI_SYSCTL0.h PERI_SYSCTL1.h PERI_SYSCTL2.h PERI_SYSPLL_T3.h PERI_SYSPLL_TCPU.h PERI_SYSPLL_TDDR.h PERI_TRNG.h PERI_USART.h PERI_USBC.h PERI_USIM.h PERI_UTICK.h PERI_WLAPU.h PERI_WWDT.h
  group utilities
    ../../../../../../devices/RW612/utilities/debug_console_lite/: fsl_assert.h fsl_assert.c
  group utilities/str
    ../../../../../../devices/RW612/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console_lite
    ../../../../../../devices/RW612/utilities/debug_console_lite/: fsl_debug_console.h fsl_debug_console.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/els_pkc/src/comps/mcuxClBuffer/src
    ../../../../../../components/els_pkc/src/comps/mcuxClBuffer/src/: mcuxClBuffer.c
  group component/els_pkc/src/comps/mcuxClBuffer/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClBuffer/inc/: mcuxClBuffer.h mcuxClBuffer_Cfg.h mcuxClBuffer_Constants.h mcuxClBuffer_Impl.h mcuxClBuffer_Pointer.h
  group component/els_pkc/src/comps/mcuxClBuffer/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClBuffer/inc/internal/: mcuxClBuffer_Internal.h mcuxClBuffer_Internal_Pointer.h
  group component/els_pkc/src/comps/mcuxClCore/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClCore/inc/: mcuxClCore_Examples.h mcuxClCore_FunctionIdentifiers.h mcuxClCore_Macros.h mcuxClCore_Platform.h mcuxClCore_Toolchain.h
  group component/els_pkc/src/comps/mcuxClEls/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClEls/inc/: mcuxClEls.h mcuxClEls_Aead.h mcuxClEls_Cipher.h mcuxClEls_Cmac.h mcuxClEls_Crc.h mcuxClEls_Ecc.h mcuxClEls_Hash.h mcuxClEls_Hmac.h mcuxClEls_Kdf.h mcuxClEls_mapping.h mcuxClEls_Rng.h mcuxClEls_Types.h mcuxClEls_KeyManagement.h mcuxClEls_Common.h mcuxClEls_GlitchDetector.h
  group component/els_pkc/src/comps/mcuxClEls/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClEls/inc/internal/: mcuxClEls_Internal.h mcuxClEls_Internal_mapping.h mcuxClEls_SfrAccess.h mcuxClEls_Internal_Common.h
  group component/els_pkc/src/comps/mcuxClEls/src
    ../../../../../../components/els_pkc/src/comps/mcuxClEls/src/: mcuxClEls_Common.c mcuxClEls_GlitchDetector.c
  group component/els_pkc/src/comps/mcuxClMemory/src
    ../../../../../../components/els_pkc/src/comps/mcuxClMemory/src/: mcuxClMemory.c
  group component/els_pkc/src/comps/mcuxClMemory/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClMemory/inc/: mcuxClMemory.h mcuxClMemory_Clear.h mcuxClMemory_Constants.h mcuxClMemory_Copy.h mcuxClMemory_Copy_Reversed.h mcuxClMemory_Endianness.h mcuxClMemory_Set.h mcuxClMemory_Types.h mcuxClMemory_Xor.h
  group component/els_pkc/src/comps/mcuxClMemory/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClMemory/inc/internal/: mcuxClMemory_Internal.h
  group component/els_pkc/src/comps/mcuxCsslMemory/src
    ../../../../../../components/els_pkc/src/comps/mcuxCsslMemory/src/: mcuxCsslMemory_Clear.c mcuxCsslMemory_Compare.c mcuxCsslMemory_Copy.c mcuxCsslMemory_Set.c
  group component/els_pkc/src/comps/mcuxCsslMemory/inc
    ../../../../../../components/els_pkc/src/comps/mcuxCsslMemory/inc/: mcuxCsslMemory.h mcuxCsslMemory_Clear.h mcuxCsslMemory_Compare.h mcuxCsslMemory_Constants.h mcuxCsslMemory_Copy.h mcuxCsslMemory_Set.h mcuxCsslMemory_Types.h
  group component/els_pkc/src/comps/mcuxCsslMemory/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxCsslMemory/inc/internal/: mcuxCsslMemory_Internal_Compare_asm.h mcuxCsslMemory_Internal_Copy_asm.h
  group component/els_pkc/src/comps/mcuxCsslCPreProcessor/inc
    ../../../../../../components/els_pkc/src/comps/mcuxCsslCPreProcessor/inc/: mcuxCsslAnalysis.h mcuxCsslCPreProcessor.h
  group component/els_pkc/src/comps/mcuxCsslDataIntegrity/inc
    ../../../../../../components/els_pkc/src/comps/mcuxCsslDataIntegrity/inc/: mcuxCsslDataIntegrity.h mcuxCsslDataIntegrity_Cfg.h mcuxCsslDataIntegrity_Impl.h mcuxCsslDataIntegrity_None.h
  group component/els_pkc/src/comps/mcuxCsslFlowProtection/inc
    ../../../../../../components/els_pkc/src/comps/mcuxCsslFlowProtection/inc/: mcuxCsslFlowProtection.h mcuxCsslFlowProtection_Cfg.h mcuxCsslFlowProtection_FunctionIdentifiers.h mcuxCsslFlowProtection_Impl.h mcuxCsslFlowProtection_SecureCounter_Common.h mcuxCsslFlowProtection_SecureCounter_Local.h
  group component/els_pkc/src/comps/mcuxCsslParamIntegrity/src
    ../../../../../../components/els_pkc/src/comps/mcuxCsslParamIntegrity/src/: mcuxCsslParamIntegrity32.c
  group component/els_pkc/src/comps/mcuxCsslParamIntegrity/inc
    ../../../../../../components/els_pkc/src/comps/mcuxCsslParamIntegrity/inc/: mcuxCsslParamIntegrity.h
  group component/els_pkc/src/comps/mcuxCsslSecureCounter/inc
    ../../../../../../components/els_pkc/src/comps/mcuxCsslSecureCounter/inc/: mcuxCsslSecureCounter.h mcuxCsslSecureCounter_Cfg.h mcuxCsslSecureCounter_Impl.h mcuxCsslSecureCounter_None.h mcuxCsslSecureCounter_SW_Local.h
  group component/els_pkc/src/compiler
    ../../../../../../components/els_pkc/src/compiler/: mcuxClToolchain.h
  group component/els_pkc/src/platforms/rw61x
    ../../../../../../components/els_pkc/src/platforms/rw61x/: platform_specific_headers.h mcuxClConfig.h
  group component/els_pkc/src/platforms/rw61x/inc
    ../../../../../../components/els_pkc/src/platforms/rw61x/inc/: ip_css_constants.h ip_css_design_configuration.h ip_platform.h
  group component/els_pkc/includes
    ../../../../../../components/els_pkc/includes/: mcuxClEls_GlitchDetector.h
  group component/els_pkc/includes/platform/rw61x
    ../../../../../../components/els_pkc/includes/platform/rw61x/: mcuxClAeadModes_MemoryConsumption.h mcuxClCipherModes_MemoryConsumption.h mcuxClEcc_MemoryConsumption.h mcuxClHashModes_MemoryConsumption.h mcuxClHash_MemoryConsumption.h mcuxClHmac_MemoryConsumption.h mcuxClKey_MemoryConsumption.h mcuxClMacModes_MemoryConsumption.h mcuxClRandomModes_MemoryConsumption.h mcuxClRsa_MemoryConsumption.h mcuxClSession_MemoryConsumption.h
  group component/conn_fwloader/include
    ../../../../../../components/conn_fwloader/include/: fsl_loader.h
  group mbedtls3x/include/mbedtls
    ../../../../../../middleware/mbedtls3x/include/mbedtls/: aes.h aria.h asn1.h asn1write.h base64.h bignum.h block_cipher.h build_info.h camellia.h ccm.h chacha20.h chachapoly.h check_config.h cipher.h cmac.h compat-2.x.h config_adjust_legacy_crypto.h config_adjust_legacy_from_psa.h config_adjust_psa_from_legacy.h config_adjust_psa_superset_legacy.h config_adjust_ssl.h config_adjust_x509.h config_psa.h constant_time.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h entropy.h error.h gcm.h hkdf.h hmac_drbg.h lms.h mbedtls_config.h md.h md5.h memory_buffer_alloc.h nist_kw.h oid.h pem.h pk.h pkcs5.h pkcs12.h platform.h platform_time.h platform_util.h poly1305.h private_access.h psa_util.h ripemd160.h rsa.h sha1.h sha3.h sha256.h sha512.h threading.h timing.h version.h pkcs7.h x509.h x509_crl.h x509_crt.h x509_csr.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_ticket.h net_sockets.h
  group mbedtls3x/include/psa
    ../../../../../../middleware/mbedtls3x/include/psa/: build_info.h crypto.h crypto_adjust_auto_enabled.h crypto_adjust_config_dependencies.h crypto_adjust_config_key_pair_types.h crypto_adjust_config_synonyms.h crypto_builtin_composites.h crypto_builtin_key_derivation.h crypto_builtin_primitives.h crypto_compat.h crypto_config.h crypto_driver_common.h crypto_driver_contexts_composites.h crypto_driver_contexts_key_derivation.h crypto_driver_contexts_primitives.h crypto_extra.h crypto_legacy.h crypto_platform.h crypto_se_driver.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h crypto_config.h
  group mbedtls3x/library
    ../../../../../../middleware/mbedtls3x/library/: aes.c aesni.c aesni.h alignment.h aesce.c aesce.h aria.c asn1parse.c asn1write.c base64.c base64_internal.h bignum.c bignum_core.h bignum_core.c bignum_core_invasive.h bignum_internal.h bignum_mod.c bignum_mod.h bignum_mod_raw.c bignum_mod_raw.h bignum_mod_raw_invasive.h block_cipher.c block_cipher_internal.h bn_mul.h camellia.c ccm.c chacha20.c chachapoly.c check_crypto_config.h cipher.c cipher_invasive.h cipher_wrap.c cipher_wrap.h cmac.c common.h constant_time.c constant_time_impl.h constant_time_internal.h ctr_drbg.c ctr.h des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c ecp_curves_new.c ecp_internal_alt.h ecp_invasive.h entropy.c entropy_poll.c entropy_poll.h error.c gcm.c hkdf.c hmac_drbg.c lmots.c lmots.h lms.c md.c md_psa.h md_wrap.h md5.c memory_buffer_alloc.c nist_kw.c oid.c padlock.c padlock.h pem.c pk.c pk_ecc.c pk_internal.h pk_wrap.c pk_wrap.h pkcs5.c pkcs12.c pkparse.c pkwrite.c pkwrite.h platform.c platform_util.c poly1305.c psa_crypto_aead.h psa_crypto_cipher.h psa_crypto_core.h psa_crypto_core_common.h psa_crypto_driver_wrappers_no_static.h psa_crypto_driver_wrappers.h psa_crypto_ecp.h psa_crypto_ffdh.h psa_crypto_hash.h psa_crypto_invasive.h psa_crypto_its.h psa_crypto_mac.h psa_crypto_pake.h psa_crypto_random.h psa_crypto_random_impl.h psa_crypto_rsa.h psa_crypto_se.h psa_crypto_slot_management.h psa_crypto_storage.h psa_util_internal.h psa_util.c ripemd160.c rsa.c rsa_alt_helpers.c rsa_alt_helpers.h rsa_internal.h sha1.c sha3.c sha256.c sha512.c threading.c threading_internal.h timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write.c x509write_crt.c x509write_csr.c x509_internal.h pkcs7.c debug.c debug_internal.h mps_common.h mps_error.h mps_reader.c mps_reader.h mps_trace.c mps_trace.h net_sockets.c ssl_cache.c ssl_ciphersuites.c ssl_ciphersuites_internal.h ssl_client.c ssl_client.h ssl_cookie.c ssl_debug_helpers.h ssl_debug_helpers_generated.c ssl_misc.h ssl_msg.c ssl_ticket.c ssl_tls.c ssl_tls12_client.c ssl_tls12_server.c ssl_tls13_client.c ssl_tls13_generic.c ssl_tls13_invasive.h ssl_tls13_keys.c ssl_tls13_keys.h ssl_tls13_server.c
  group mbedtls3x/port
    ../../../../../../middleware/mbedtls3x/port/: mcux_mbedtls_config.h mcux_mbedtls_accelerator_config.h mcux_mbedtls_config.h mcux_mbedtls_accelerator_config.h mcux_psa_defines.h
  group mbedtls3x/port/tfm
    ../../../../../../middleware/mbedtls3x/port/tfm/: entropy_poll_alt.c
  group tf-m/platform/ext/target/nxp/common
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/: target_cfg_common.h libc_dummy.c tfm_hal_ns_init.c
  group tf-m/platform/ext/target/nxp/common/Device/Include
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/Device/Include/: cmsis.h device_definition.h platform_irq.h platform_regs.h
  group tf-m/platform/ext/target/nxp/common/Device/Config
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/Device/Config/: device_cfg.h
  group tf-m/platform/ext/target/nxp/common/CMSIS_Driver
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/CMSIS_Driver/: Driver_USART.c
  group tf-m/platform/ext/target/nxp/frdmrw612
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/frdmrw612/: platform_psa_hw_accel.h config_tfm_target.h target_cfg.h tfm_peripherals_def.h
  group tf-m/platform/ext/target/nxp/frdmrw612/Device/Include
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/frdmrw612/Device/Include/: platform_base_address.h
  group tf-m/platform/ext/target/nxp/frdmrw612/Device/Source
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/frdmrw612/Device/Source/: startup_frdmrw612.c
  group tf-m/platform/ext/target/nxp/frdmrw612/partition
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/frdmrw612/partition/: region_defs.h flash_layout.h
  group tf-m/platform/ext/target/nxp/rw61x/platform/include
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/rw61x/platform/include/: platform_nv_counters_ids.h
  group tf-m/platform/ext/target/nxp/rw61x/partitions/loader_service
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/rw61x/partitions/loader_service/: tfm_lds_sid.h tfm_lds_func_ids.h
  group tf-m/platform/ext/target/nxp/rw61x/partitions/loader_service/interface/include
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/rw61x/partitions/loader_service/interface/include/: tfm_lds_defs.h
  group tf-m/platform/ext/target/nxp/rw61x/partitions/loader_service/interface/src
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/rw61x/partitions/loader_service/interface/src/: tfm_lds_api.c
  group tf-m/platform/ext/target/nxp/rw61x/plat_iak_pk
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/rw61x/plat_iak_pk/: plat_iak_pk.c plat_iak_pk.h
  group tf-m/platform/ext/driver
    ../../../../../../middleware/tfm/tf-m/platform/ext/driver/: Driver_Common.h Driver_Flash.h Driver_MPC.h Driver_PPC.h Driver_USART.h Driver_USART.h Driver_Common.h
  group tf-m/platform/ext/common
    ../../../../../../middleware/tfm/tf-m/platform/ext/common/: uart_stdout.h uart_stdout.c
  group tf-m/platform/include
    ../../../../../../middleware/tfm/tf-m/platform/include/: tfm_plat_crypto_keys.h tfm_hal_device_header.h tfm_plat_boot_seed.h tfm_plat_device_id.h tfm_plat_defs.h tfm_plat_ns.h region.h tfm_plat_test.h
  group tf-m/interface/include
    ../../../../../../middleware/tfm/tf-m/interface/include/: tfm_attest_defs.h config_impl.h tfm_crypto_defs.h tfm_its_defs.h tfm_ps_defs.h tfm_veneers.h tfm_ns_interface.h tfm_psa_call_pack.h tfm_ns_client_ext.h tfm_platform_api.h
  group tf-m/interface/include/crypto_keys
    ../../../../../../middleware/tfm/tf-m/interface/include/crypto_keys/: tfm_builtin_key_ids.h
  group tf-m/interface/include/psa_manifest
    ../../../../../../middleware/tfm/tf-m/interface/include/psa_manifest/: sid.h
  group tf-m/interface/include/os_wrapper
    ../../../../../../middleware/tfm/tf-m/interface/include/os_wrapper/: common.h mutex.h
  group tf-m/interface/include/psa
    ../../../../../../middleware/tfm/tf-m/interface/include/psa/: client.h crypto.h crypto_compat.h crypto_extra.h crypto_platform.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h error.h framework_feature.h initial_attestation.h internal_trusted_storage.h lifecycle.h protected_storage.h service.h storage_common.h
  group tf-m/interface/src
    ../../../../../../middleware/tfm/tf-m/interface/src/: tfm_crypto_api.c tfm_attest_api.c tfm_its_api.c tfm_ps_api.c tfm_platform_api.c tfm_tz_psa_ns_api.c
  group tf-m/interface/src/os_wrapper
    ../../../../../../middleware/tfm/tf-m/interface/src/os_wrapper/: tfm_ns_interface_bare_metal.c
  group tf-m/secure_fw/spm/include
    ../../../../../../middleware/tfm/tf-m/secure_fw/spm/include/: tfm_arch.h tfm_arch_v8m.h utilities.h
  group tf-m/secure_fw/include
    ../../../../../../middleware/tfm/tf-m/secure_fw/include/: config_tfm.h
  group tf-m/secure_fw/partitions/crypto
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/crypto/: config_crypto_check.h
  group tf-m/secure_fw/partitions/protected_storage
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/protected_storage/: config_ps_check.h
  group tf-m/config
    ../../../../../../middleware/tfm/tf-m/config/: config_base.h
  group tfm/tf-m/platform/include
    ../../../../../../middleware/tfm/tf-m/platform/include/: boot_hal.h cmsis_override.h exception_info.h fatal_error.h mbedtls_entropy_nv_seed_config.h region.h tfm_attest_hal.h tfm_hal_defs.h tfm_hal_device_header.h tfm_hal_interrupt.h tfm_hal_isolation.h tfm_hal_its.h tfm_hal_its_encryption.h tfm_hal_mailbox.h tfm_hal_multi_core.h tfm_hal_platform.h tfm_hal_ps.h tfm_plat_boot_seed.h tfm_plat_config.h tfm_plat_crypto_keys.h tfm_plat_crypto_nv_seed.h tfm_plat_defs.h tfm_plat_device_id.h tfm_plat_ns.h tfm_plat_nv_counters.h tfm_plat_otp.h tfm_plat_provisioning.h tfm_plat_rotpk.h tfm_plat_test.h tfm_platform_system.h
  group tfm/tf-m/interface/include
    ../../../../../../middleware/tfm/tf-m/interface/include/: config_impl.h tfm_attest_defs.h tfm_attest_iat_defs.h tfm_crypto_defs.h tfm_fwu_defs.h tfm_its_defs.h tfm_ns_client_ext.h tfm_ns_interface.h tfm_platform_api.h tfm_ps_defs.h tfm_psa_call_pack.h tfm_veneers.h
  group tfm/tf-m/interface/include/psa_manifest
    ../../../../../../middleware/tfm/tf-m/interface/include/psa_manifest/: sid.h pid.h
  group tfm/tf-m/interface/include/psa
    ../../../../../../middleware/tfm/tf-m/interface/include/psa/: build_info.h client.h crypto.h crypto_adjust_auto_enabled.h crypto_adjust_config_dependencies.h crypto_adjust_config_key_pair_types.h crypto_adjust_config_synonyms.h crypto_builtin_composites.h crypto_builtin_key_derivation.h crypto_builtin_primitives.h crypto_compat.h crypto_driver_common.h crypto_driver_contexts_composites.h crypto_driver_contexts_key_derivation.h crypto_driver_contexts_primitives.h crypto_extra.h crypto_legacy.h crypto_platform.h crypto_se_driver.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h error.h framework_feature.h initial_attestation.h internal_trusted_storage.h lifecycle.h protected_storage.h service.h storage_common.h update.h
  group tfm/tf-m/interface/include/mbedtls
    ../../../../../../middleware/tfm/tf-m/interface/include/mbedtls/: aes.h aria.h asn1.h asn1write.h base64.h bignum.h block_cipher.h build_info.h camellia.h ccm.h chacha20.h chachapoly.h check_config.h cipher.h cmac.h compat-2.x.h config_adjust_legacy_crypto.h config_adjust_legacy_from_psa.h config_adjust_psa_from_legacy.h config_adjust_psa_superset_legacy.h config_adjust_ssl.h config_adjust_x509.h config_psa.h constant_time.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h entropy.h error.h gcm.h hkdf.h hmac_drbg.h lms.h md.h md5.h memory_buffer_alloc.h net_sockets.h nist_kw.h oid.h pem.h pk.h pkcs12.h pkcs5.h pkcs7.h platform.h platform_time.h platform_util.h poly1305.h private_access.h psa_util.h ripemd160.h rsa.h sha1.h sha256.h sha3.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h
  group tfm/tf-m/interface/include/crypto_keys
    ../../../../../../middleware/tfm/tf-m/interface/include/crypto_keys/: tfm_builtin_key_ids.h
  group tfm/tf-m/lib/ext/mbedcrypto/mbedcrypto_config
    ../../../../../../middleware/tfm/tf-m/lib/ext/mbedcrypto/mbedcrypto_config/: tfm_mbedcrypto_config_profile_large_client.h
  group tfm/tf-m/config/profile
    ../../../../../../middleware/tfm/tf-m/config/profile/: config_profile_large.h
  group doc
    ../: readme.md
