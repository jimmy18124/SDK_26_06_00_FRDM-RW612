# IAR project tfm_regression_s.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: RW612 NXP RW612
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; PRINTF_ADVANCED_ENABLE=1; OCOTP_NV_COUNTERS_RAM_EMULATION=1; TFM_FIH_PROFILE_ON; TFM_FIH_PROFILE_MEDIUM; FIH_CFI_ALT; TFM_SPM_LOG_LEVEL=TFM_SPM_LOG_LEVEL_INFO; TFM_SP_LOG_RAW_ENABLED; TFM_PARTITION_LOG_LEVEL=TFM_PARTITION_LOG_LEVEL_INFO; PS_WIPE_ALL; ITS_WIPE_ALL; DAUTH_CHIP_DEFAULT; __SEMIHOST_HARDFAULT_DISABLE; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_RW612ETA2I; RW612_SERIES; OSA_USED; BOOT_HEADER_ENABLE=1; USE_RTOS=0; WIFI_BOARD_FRDM_RW61X; PSA_CRYPTO_DRIVER_ELS_PKC; MBEDTLS_MCUX_USE_TRNG_AS_ENTROPY_SEED; MFLASH_FILE_BASEADDR=7340032; TARGET_CONFIG_HEADER_FILE="config_tfm_target.h"; CONFIG_TFM_BUILDING_SPE=1; CONFIG_TFM_ENABLE_MEMORY_PROTECT; TFM_PARTITION_NS_AGENT_TZ; TFM_PARTITION_IDLE; PLATFORM_DEFAULT_OTP; PLATFORM_DEFAULT_PROVISIONING; OTP_WRITEABLE; TFM_DUMMY_PROVISIONING; CONFIG_TFM_FLOAT_ABI=2; CONFIG_TFM_ENABLE_CP10CP11; CONFIG_TFM_LAZY_STACKING; CONFIG_TFM_HALT_ON_CORE_PANIC; CONFIG_TFM_USE_TRUSTZONE; USE_SGI_HUK; USE_ELS_PKC_HUK; USE_ELS_PKC_IAK; HARDENING_MACROS_ENABLED; PSA_WANT_ECC_SECP_R1_224; CRYPTO_HW_ACCELERATOR; TFM_PARTITION_PLATFORM; TFM_PARTITION_CRYPTO; PLATFORM_DEFAULT_CRYPTO_KEYS; MBEDTLS_PSA_CRYPTO_DRIVERS; PSA_CRYPTO_DRIVER_TFM_BUILTIN_KEY; PSA_CRYPTO_DRIVER_TFM_BUILTIN_KEY_LOADER; PS_CRYPTO_AEAD_ALG=PSA_ALG_CCM; TFM_PARTITION_INITIAL_ATTESTATION; ATTEST_TOKEN_PROFILE_PSA_IOT_1; TEST_NS_ATTESTATION; TEST_S_ATTESTATION; PS_ENCRYPTION; PS_ROLLBACK_PROTECTION; TFM_PARTITION_PROTECTED_STORAGE; TEST_S_PS; TFM_PARTITION_INTERNAL_TRUSTED_STORAGE; TFM_PARTITION_LOADER_SERVICE; TFM_ISOLATION_LEVEL=2; CONFIG_TFM_PARTITION_META; CONFIG_TFM_SPM_BACKEND_IPC=1; PROJECT_CONFIG_HEADER_FILE="config_profile_large.h"; MBEDTLS_CONFIG_FILE="tfm_mbedcrypto_config_profile_large.h"; MBEDTLS_PSA_CRYPTO_CONFIG_FILE="crypto_config_profile_large.h"; PSA_WANT_ALG_SHA_512_224; PSA_WANT_ALG_SHA_512_256; TFM_CRYPTO_TEST_ALG_CBC; TFM_CRYPTO_TEST_ALG_CCM; TFM_CRYPTO_TEST_ALG_GCM; TFM_CRYPTO_TEST_ALG_SHA_512; TFM_CRYPTO_TEST_HKDF; TFM_CRYPTO_TEST_ECDH; TFM_CRYPTO_TEST_UNSUPPORTED_ALG; TFM_S_REG_TEST; USE_SP_LOG; MCU_SDK_REGRESSION; TEST_S_PLATFORM; TEST_S_CRYPTO; TEST_S_ITS; TFM_PARTITION_TEST_PS; TFM_PARTITION_IPC_TEST; TEST_S_IPC; TFM_PARTITION_SLIH_TEST
  ICCARM.CCDiagSuppress: Pa039,Pa082,Pa050,Pa205,Pa084,Pe546,Pe550,Pe940,Pe188,Pe186,Pe177,Pe111,Pe174,Pe128,Pe161,Pe068,Pe223,Pa181
  ICCARM.IExtraOptions: --preinclude ../mcuxsdk_version.h --diag_suppress=Pe111,Pe546,Pe550,Pa217 --cmse  --diag_suppress=Pe111,Pe546,Pe550,Pa217
  ICCARM.PreInclude: ../mcux_config.h
  ICCARM.CCIncludePath2: ..; ../../../../flash_config; ../../../../../../devices/RW612/drivers; ../../../../../../devices/RW612/drivers/romapi/bootloader; ../../../../../../devices/RW612/drivers/romapi/flexspi; ../../../../../../devices/RW612/drivers/romapi/iap; ../../../../../../devices/RW612/drivers/romapi/nboot; ../../../../../../devices/RW612/drivers/romapi/otp; ../../../../../../CMSIS/Core/Include; ../../../../../../CMSIS/Core/Include/m-profile; ../../../../../../devices/RW612; ../../../../../../devices/RW612/periph; ../../../../../../devices/RW612/utilities/debug_console_lite; ../../../../../../components/lists; ../../../../../../devices/RW612/utilities/str; ../../../../../../components/uart; ../../../../../../components/osa; ../../../../../../components/wifi_bt_module/incl; ../../../../../../components/els_pkc; ../../../../../../components/els_pkc/src/comps/mcuxClAead/inc; ../../../../../../components/els_pkc/src/comps/mcuxClAead/inc/internal; ../../../../../../components/els_pkc/src/comps/mcuxClAeadModes/inc; ../../../../../../components/els_pkc/src/comps/mcuxClAeadModes/inc/internal; ../../../../../../components/els_pkc/src/comps/mcuxClAes/inc; ../../../../../../components/els_pkc/src/comps/mcuxClAes/inc/internal; ../../../../../../components/els_pkc/src/comps/mcuxClBuffer/inc; ../../../../../../components/els_pkc/src/comps/mcuxClBuffer/inc/internal; ../../../../../../components/els_pkc/src/comps/mcuxClCipher/inc; ../../../../../../components/els_pkc/src/comps/mcuxClCipher/inc/internal; ../../../../../../components/els_pkc/src/comps/mcuxClCipherModes/inc; ../../../../../../components/els_pkc/src/comps/mcuxClCipherModes/inc/internal; ../../../../../../components/els_pkc/src/comps/mcuxClCore/inc; ../../../../../../components/els_pkc/src/comps/mcuxClEcc/inc; ../../../../../../components/els_pkc/src/comps/mcuxClEcc/inc/internal; ../../../../../../components/els_pkc/src/comps/mcuxClEls/inc; ../../../../../../components/els_pkc/src/comps/mcuxClEls/inc/internal; ../../../../../../components/els_pkc/src/comps/mcuxClHash/inc; ../../../../../../components/els_pkc/src/comps/mcuxClHash/inc/internal; ../../../../../../components/els_pkc/src/comps/mcuxClHashModes/inc; ../../../../../../components/els_pkc/src/comps/mcuxClHashModes/inc/internal; ../../../../../../components/els_pkc/src/comps/mcuxClHmac/inc; ../../../../../../components/els_pkc/src/comps/mcuxClHmac/inc/internal; ../../../../../../components/els_pkc/src/comps/mcuxClKey/inc; ../../../../../../components/els_pkc/src/comps/mcuxClKey/inc/internal; ../../../../../../components/els_pkc/src/comps/mcuxClMac/inc; ../../../../../../components/els_pkc/src/comps/mcuxClMac/inc/internal; ../../../../../../components/els_pkc/src/comps/mcuxClMacModes/inc; ../../../../../../components/els_pkc/src/comps/mcuxClMacModes/inc/internal; ../../../../../../components/els_pkc/src/comps/mcuxClMath/inc; ../../../../../../components/els_pkc/src/comps/mcuxClMath/inc/internal; ../../../../../../components/els_pkc/src/comps/mcuxClMemory/inc; ../../../../../../components/els_pkc/src/comps/mcuxClMemory/inc/internal; ../../../../../../components/els_pkc/src/comps/mcuxCsslMemory/inc; ../../../../../../components/els_pkc/src/comps/mcuxCsslMemory/inc/internal; ../../../../../../components/els_pkc/src/comps/mcuxClPadding/inc; ../../../../../../components/els_pkc/src/comps/mcuxClPadding/inc/internal; ../../../../../../components/els_pkc/src/comps/mcuxClPkc/inc; ../../../../../../components/els_pkc/src/comps/mcuxClPkc/inc/internal; ../../../../../../components/els_pkc/src/comps/mcuxClPrng/inc; ../../../../../../components/els_pkc/src/comps/mcuxClPrng/inc/internal; ../../../../../../components/els_pkc/src/comps/mcuxClPsaDriver/inc; ../../../../../../components/els_pkc/src/comps/mcuxClPsaDriver/inc/internal; ../../../../../../components/els_pkc/src/comps/mcuxClRandom/inc; ../../../../../../components/els_pkc/src/comps/mcuxClRandom/inc/internal; ../../../../../../components/els_pkc/src/comps/mcuxClRandomModes/inc; ../../../../../../components/els_pkc/src/comps/mcuxClRandomModes/inc/internal; ../../../../../../components/els_pkc/src/comps/mcuxClRsa/inc; ../../../../../../components/els_pkc/src/comps/mcuxClRsa/inc/internal; ../../../../../../components/els_pkc/src/comps/mcuxClSession/inc; ../../../../../../components/els_pkc/src/comps/mcuxClSession/inc/internal; ../../../../../../components/els_pkc/src/comps/mcuxClTrng/inc; ../../../../../../components/els_pkc/src/comps/mcuxClTrng/inc/internal; ../../../../../../components/els_pkc/src/comps/mcuxCsslCPreProcessor/inc; ../../../../../../components/els_pkc/src/comps/mcuxCsslDataIntegrity/inc; ../../../../../../components/els_pkc/src/comps/mcuxCsslFlowProtection/inc; ../../../../../../components/els_pkc/src/comps/mcuxCsslParamIntegrity/inc; ../../../../../../components/els_pkc/src/comps/mcuxCsslSecureCounter/inc; ../../../../../../components/els_pkc/src/inc; ../../../../../../components/els_pkc/src/compiler; ../../../../../../components/els_pkc/src/platforms/rw61x; ../../../../../../components/els_pkc/src/platforms/rw61x/inc; ../../../../../../components/els_pkc/includes/platform/rw61x; ../../../../../../components/psa_crypto_driver/osal; ../../../../../../components/psa_crypto_driver/osal/baremetal; ../../../../../../components/psa_crypto_driver/els_pkc/oracle/platforms/rw61x; ../../../../../../components/psa_crypto_driver/els_pkc/oracle/inc; ../../../../../../components/psa_crypto_driver/els_pkc/include/common; ../../../../../../components/psa_crypto_driver/els_pkc/include/transparent; ../../../../../../components/psa_crypto_driver/els_pkc/include/opaque; ../../../../../../components/psa_crypto_driver/els_pkc; ../../../../../../components/flash/mflash; ../../../../../../components/flash/mflash/frdmrw612; ../../../../../../components/conn_fwloader/include; ../../../../../../components/conn_fwloader/fw_bin; ../../../../../../components/conn_fwloader/fw_bin/inc/rw61x; ../../../../../../components/conn_fwloader/fw_bin/rw61x; ../../../../../../components/conn_fwloader/fw_bin/inc/iw610x; ../../../../../../components/conn_fwloader/fw_bin/iw610x; ../../../../../../components/conn_fwloader/fw_bin/inc/8987; ../../../../../../components/conn_fwloader/fw_bin/8987; ../../../../../../components/conn_fwloader/fw_bin/inc/IW416; ../../../../../../components/conn_fwloader/fw_bin/IW416; ../../../../../../components/conn_fwloader/fw_bin/inc/nw61x; ../../../../../../components/conn_fwloader/fw_bin/nw61x; ../../../../../../components/conn_fwloader/fw_bin/script; ../../../../../../middleware/mbedtls3x/include; ../../../../../../middleware/mbedtls3x/include/mbedtls; ../../../../../../middleware/mbedtls3x/library; ../../../../../../middleware/mbedtls3x/port; ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common; ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/frdmrw612; ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/frdmrw612/partition; ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/frdmrw612/Device/Include; ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/rw61x/platform/include; ../../../../../../middleware/tfm/tf-m/platform/ext/driver; ../../../../../../middleware/tfm/tf-m/platform/include; ../../../../../../middleware/tfm/tf-m/interface/include; ../../../../../../middleware/tfm/tf-m/interface/include/psa; ../../../../../../middleware/tfm/tf-m/interface/include/crypto_keys; ../../../../../../middleware/tfm/tf-m/interface/include/psa_manifest; ../../../../../../middleware/tfm/tf-m; ../../../../../../middleware/tfm/tf-m/config; ../../../../../../middleware/tfm/tf-m/lib/fih/inc; ../../../../../../middleware/tfm/tf-m/platform/ext; ../../../../../../middleware/tfm/tf-m/platform/ext/common; ../../../../../../middleware/tfm/tf-m/platform/ext/common/template; ../../../../../../middleware/tfm/tf-m/platform/ext/target/arm/drivers/mpu/armv8m; ../../../../../../middleware/tfm/tf-m/platform/ext/accelerator/interface; ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/Device/Config; ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/Device/Include; ../../../../../../middleware/tfm/tf-m/secure_fw/include; ../../../../../../middleware/tfm/tf-m/secure_fw/spm; ../../../../../../middleware/tfm/tf-m/secure_fw/spm/include; ../../../../../../middleware/tfm/tf-m/secure_fw/spm/core; ../../../../../../middleware/tfm/tf-m/secure_fw/spm/include/boot; ../../../../../../middleware/tfm/tf-m/secure_fw/spm/include/ffm; ../../../../../../middleware/tfm/tf-m/secure_fw/spm/include/interface; ../../../../../../middleware/tfm/tf-m/secure_fw/partitions; ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/crypto/psa_manifest; ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/initial_attestation/psa_manifest; ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/internal_trusted_storage/psa_manifest; ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/lib/runtime; ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/lib/runtime/include; ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/crypto/auto_generated; ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/crypto; ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/crypto/psa_driver_api; ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/rw61x; ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/platform; ../../../../../../middleware/tfm/tf-m/lib/ext/mbedcrypto/mbedcrypto_config; ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/initial_attestation/auto_generated; ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/initial_attestation; ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/protected_storage/psa_manifest; ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/protected_storage/crypto; ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/protected_storage; ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/protected_storage/auto_generated; ../../../../../../middleware/tfm; ../../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/suites/ps/secure; ../../../../../../middleware/tfm/tf-m/autogenerated/secure_fw/test_services/tfm_ps_test_service; ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/internal_trusted_storage; ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/internal_trusted_storage/flash; ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/internal_trusted_storage/flash_fs; ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/rw61x/partitions/loader_service; ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/rw61x/partitions/loader_service/psa_manifest; ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/rw61x/partitions/loader_service/interface/include; ../../../../../../middleware/tfm/tf-m/config/profile; ../../../../../../middleware/tfm/tf-m-tests/tests_reg/test/framework; ../../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_regression; ../../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/common_test_services/tfm_secure_client_service; ../../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/common_test_services/tfm_secure_client_2; ../../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/suites/spm/ipc/secure; ../../../../../../middleware/tfm/tf-m/autogenerated/secure_fw/test_services/tfm_secure_client_service/psa_manifest; ../../../../../../middleware/tfm/tf-m/autogenerated/secure_fw/test_services/tfm_secure_client_service; ../../../../../../middleware/tfm/tf-m/autogenerated/secure_fw/test_services/tfm_secure_client_2/psa_manifest; ../../../../../../middleware/tfm/tf-m/autogenerated/secure_fw/test_services/tfm_secure_client_2; ../../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/suites/platform/secure; ../../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/suites/attestation/secure; ../../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/suites/crypto/secure; ../../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/suites/its/secure; ../../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/suites/platform; ../../../../../../middleware/tfm/tf-m/autogenerated/secure_fw/test_services/tfm_ipc_service/psa_manifest; ../../../../../../middleware/tfm/tf-m/autogenerated/secure_fw/test_services/tfm_ipc_service; ../../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/suites/spm/common; ../../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/suites/spm/common/suites; ../../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/suites/spm/common/service; ../../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/suites/spm/ipc/service/tfm_ipc_service; ../../../../../../middleware/tfm/tf-m/autogenerated/secure_fw/test_services/tfm_ipc_client/psa_manifest; ../../../../../../middleware/tfm/tf-m/autogenerated/secure_fw/test_services/tfm_ipc_client; ../../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/suites/spm/ipc/service/tfm_ipc_client; ../../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/suites/spm/irq/service/tfm_slih_test_service; ../../../../../../middleware/tfm/tf-m/autogenerated/secure_fw/test_services/tfm_slih_test_service; ../../../../../../middleware/tfm/tf-m/autogenerated/secure_fw/test_services/tfm_slih_test_service/psa_manifest
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: MCUXPRESSO_SDK; CPU_RW612ETA2I; RW612_SERIES; OSA_USED
  AARM.AUserIncludes: as above
  AARM.PreInclude: ../mcux_config.h
  ILINK.IlinkOutputFile: tfm_regression_s.out
  ILINK.IlinkIcfFile: ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/iar/tfm_common_s_pre.icf
  ILINK.IlinkAdditionalLibs: ../../../../lib_projects/tfm_s_crypto_clients/iar/debug/tfm_s_crypto_clients.a; ../../../../lib_projects/tfm_s_reg_suites/iar/debug/tfm_s_reg_suites.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; PRINTF_ADVANCED_ENABLE=1; OCOTP_NV_COUNTERS_RAM_EMULATION=1; TFM_FIH_PROFILE_ON; TFM_FIH_PROFILE_MEDIUM; FIH_CFI_ALT; TFM_SPM_LOG_LEVEL=TFM_SPM_LOG_LEVEL_INFO; TFM_SP_LOG_RAW_ENABLED; TFM_PARTITION_LOG_LEVEL=TFM_PARTITION_LOG_LEVEL_INFO; PS_WIPE_ALL; ITS_WIPE_ALL; DAUTH_CHIP_DEFAULT; __SEMIHOST_HARDFAULT_DISABLE; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_RW612ETA2I; RW612_SERIES; OSA_USED; BOOT_HEADER_ENABLE=1; USE_RTOS=0; WIFI_BOARD_FRDM_RW61X; PSA_CRYPTO_DRIVER_ELS_PKC; MBEDTLS_MCUX_USE_TRNG_AS_ENTROPY_SEED; MFLASH_FILE_BASEADDR=7340032; TARGET_CONFIG_HEADER_FILE="config_tfm_target.h"; CONFIG_TFM_BUILDING_SPE=1; CONFIG_TFM_ENABLE_MEMORY_PROTECT; TFM_PARTITION_NS_AGENT_TZ; TFM_PARTITION_IDLE; PLATFORM_DEFAULT_OTP; PLATFORM_DEFAULT_PROVISIONING; OTP_WRITEABLE; TFM_DUMMY_PROVISIONING; CONFIG_TFM_FLOAT_ABI=2; CONFIG_TFM_ENABLE_CP10CP11; CONFIG_TFM_LAZY_STACKING; CONFIG_TFM_HALT_ON_CORE_PANIC; CONFIG_TFM_USE_TRUSTZONE; USE_SGI_HUK; USE_ELS_PKC_HUK; USE_ELS_PKC_IAK; HARDENING_MACROS_ENABLED; PSA_WANT_ECC_SECP_R1_224; CRYPTO_HW_ACCELERATOR; TFM_PARTITION_PLATFORM; TFM_PARTITION_CRYPTO; PLATFORM_DEFAULT_CRYPTO_KEYS; MBEDTLS_PSA_CRYPTO_DRIVERS; PSA_CRYPTO_DRIVER_TFM_BUILTIN_KEY; PSA_CRYPTO_DRIVER_TFM_BUILTIN_KEY_LOADER; PS_CRYPTO_AEAD_ALG=PSA_ALG_CCM; TFM_PARTITION_INITIAL_ATTESTATION; ATTEST_TOKEN_PROFILE_PSA_IOT_1; TEST_NS_ATTESTATION; TEST_S_ATTESTATION; PS_ENCRYPTION; PS_ROLLBACK_PROTECTION; TFM_PARTITION_PROTECTED_STORAGE; TEST_S_PS; TFM_PARTITION_INTERNAL_TRUSTED_STORAGE; TFM_PARTITION_LOADER_SERVICE; TFM_ISOLATION_LEVEL=2; CONFIG_TFM_PARTITION_META; CONFIG_TFM_SPM_BACKEND_IPC=1; PROJECT_CONFIG_HEADER_FILE="config_profile_large.h"; MBEDTLS_CONFIG_FILE="tfm_mbedcrypto_config_profile_large.h"; MBEDTLS_PSA_CRYPTO_CONFIG_FILE="crypto_config_profile_large.h"; PSA_WANT_ALG_SHA_512_224; PSA_WANT_ALG_SHA_512_256; TFM_CRYPTO_TEST_ALG_CBC; TFM_CRYPTO_TEST_ALG_CCM; TFM_CRYPTO_TEST_ALG_GCM; TFM_CRYPTO_TEST_ALG_SHA_512; TFM_CRYPTO_TEST_HKDF; TFM_CRYPTO_TEST_ECDH; TFM_CRYPTO_TEST_UNSUPPORTED_ALG; TFM_S_REG_TEST; USE_SP_LOG; MCU_SDK_REGRESSION; TEST_S_PLATFORM; TEST_S_CRYPTO; TEST_S_ITS; TFM_PARTITION_TEST_PS; TFM_PARTITION_IPC_TEST; TEST_S_IPC; TFM_PARTITION_SLIH_TEST
  ICCARM.IExtraOptions: --preinclude ../mcuxsdk_version.h --diag_suppress=Pa082,Pa050  --diag_suppress=Pe111,Pe546,Pe550,Pa217 --cmse  --diag_suppress=Pa082,Pa050  --diag_suppress=Pe111,Pe546,Pe550,Pa217
  ILINK.IlinkAdditionalLibs: ../../../../lib_projects/tfm_s_crypto_clients/iar/release/tfm_s_crypto_clients.a; ../../../../lib_projects/tfm_s_reg_suites/iar/release/tfm_s_reg_suites.a
  group board
    ../: board.h board.c clock_config.h clock_config.c pin_mux.h pin_mux.c hardware_init.c app.h
  group flash_config
    ../../../../flash_config/: flash_config.c flash_config.h
  group drivers
    ../../../../../../devices/RW612/drivers/: fsl_clock.c fsl_clock.h fsl_i2s_bridge.c fsl_i2s_bridge.h fsl_inputmux_connections.h fsl_io_mux.h fsl_iped.c fsl_iped.h fsl_memory.h fsl_ocotp.c fsl_ocotp.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_cache.c fsl_cache.h fsl_cdog.h fsl_cdog.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_ctimer.h fsl_ctimer.c fsl_flexcomm.h fsl_flexcomm.c fsl_usart.h fsl_usart.c fsl_flexspi.c fsl_flexspi.h fsl_gpio.h fsl_gpio.c fsl_trng.c fsl_trng.h
  group drivers/romapi/bootloader
    ../../../../../../devices/RW612/drivers/romapi/bootloader/: fsl_romapi.c fsl_romapi.h
  group drivers/romapi/flexspi
    ../../../../../../devices/RW612/drivers/romapi/flexspi/: fsl_romapi_flexspi.c fsl_romapi_flexspi.h
  group drivers/romapi/iap
    ../../../../../../devices/RW612/drivers/romapi/iap/: fsl_kb_api.h fsl_romapi_iap.c fsl_romapi_iap.h fsl_sbloader_v3.h
  group drivers/romapi/nboot
    ../../../../../../devices/RW612/drivers/romapi/nboot/: fsl_romapi_nboot.c fsl_romapi_nboot.h
  group drivers/romapi/otp
    ../../../../../../devices/RW612/drivers/romapi/otp/: fsl_romapi_otp.c fsl_romapi_otp.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    ../../../../../../CMSIS/Core/Include/m-profile/: cmsis_iccarm_m.h armv8m_mpu.h
  group device
    ../../../../../../devices/RW612/: fsl_device_registers.h RW612.h RW612_features.h RW612_COMMON.h system_RW612.c system_RW612.h
  group device/periph
    ../../../../../../devices/RW612/periph/: PERI_ACOMP.h PERI_ADC.h PERI_AHB_SECURE_CTRL.h PERI_AON_SOC_CIU.h PERI_APU.h PERI_BG.h PERI_BLEAPU.h PERI_BUCK11.h PERI_BUCK18.h PERI_CACHE64_CTRL.h PERI_CACHE64_POLSEL.h PERI_CAU.h PERI_CDOG.h PERI_CIU1.h PERI_CIU2.h PERI_CLKCTL0.h PERI_CLKCTL1.h PERI_CRC.h PERI_CTIMER.h PERI_DAC.h PERI_DBGMAILBOX.h PERI_DMA.h PERI_DMIC.h PERI_ELS.h PERI_ENET.h PERI_FLEXCOMM.h PERI_FLEXSPI.h PERI_FREQME.h PERI_GDMA.h PERI_GPIO.h PERI_I2C.h PERI_I2S.h PERI_INPUTMUX.h PERI_ITRC.h PERI_LCDIC.h PERI_MCI_IO_MUX.h PERI_MRT.h PERI_OCOTP.h PERI_OSTIMER.h PERI_PINT.h PERI_PKC.h PERI_PMU.h PERI_POWERQUAD.h PERI_PUF.h PERI_RF_SYSCON.h PERI_ROMCP.h PERI_RSTCTL0.h PERI_RSTCTL1.h PERI_RTC.h PERI_SCT.h PERI_SDU_FBR_CARD.h PERI_SDU_FN0_CARD.h PERI_SDU_FN_CARD.h PERI_SENSOR_CTRL.h PERI_SOCCIU.h PERI_SOC_OTP_CTRL.h PERI_SPI.h PERI_SYSCTL0.h PERI_SYSCTL1.h PERI_SYSCTL2.h PERI_SYSPLL_T3.h PERI_SYSPLL_TCPU.h PERI_SYSPLL_TDDR.h PERI_TRNG.h PERI_USART.h PERI_USBC.h PERI_USIM.h PERI_UTICK.h PERI_WLAPU.h PERI_WWDT.h
  group utilities
    ../../../../../../devices/RW612/utilities/debug_console_lite/: fsl_assert.h fsl_assert.c
  group utilities/str
    ../../../../../../devices/RW612/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console_lite
    ../../../../../../devices/RW612/utilities/debug_console_lite/: fsl_debug_console.h fsl_debug_console.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/osa
    ../../../../../../components/osa/: fsl_os_abstraction_bm.h fsl_os_abstraction_bm.c fsl_os_abstraction.h
  group component/wifi_bt_module/incl
    ../../../../../../components/wifi_bt_module/incl/: wifi_bt_module_config.h
  group component/els_pkc
    ../../../../../../components/els_pkc/: LICENSE.txt softwareContentRegister.txt ReleaseNotes.txt
  group component/els_pkc/doc/rw61x/html
    ../../../../../../components/els_pkc/doc/rw61x/html/: a00002.html a00002.js a00005.html a00005.js a00008.html a00008.js a00011.html a00011.js a00014.html a00014.js a00017.html a00017.js a00020.html a00020.js a00023.html a00023.js a00026.html a00026.js a00029.html a00029.js a00032.html a00032.js a00035.html a00035.js a00038.html a00038.js a00071.html a00071.js a00074.html a00074.js a00077.html a00080.html a00083.html a00086.html a00089.html a00128.html a00128.js a00131.html a00131.js a00149.html a00149.js a00152.html a00152.js a00155.html a00155.js a00158.html a00158.js a00161.html a00161.js a00164.html a00164.js a00167.html a00167.js a00170.html a00170.js a00173.html a00173.js a00176.html a00176.js a00179.html a00179.js a00182.html a00182.js a00266.html a00272.html a00275.html a00278.html a00281.html a00284.html a00302_source.html a00305_source.html a00311_source.html a00314_source.html a00317.html a00317.js a00317_source.html a00320_source.html a00323.html a00323_source.html a00326_source.html a00329.html a00329.js a00329_source.html a00332.html a00332.js a00332_source.html a00335.html a00335.js a00335_source.html a00338.html a00338.js a00338_source.html a00341.html a00341_source.html a00344_source.html a00347.html a00347.js a00347_source.html a00350.html a00350.js a00350_source.html a00353.html a00353.js a00353_source.html a00356.html a00356.js a00356_source.html a00359.html a00359.js a00359_source.html a00362.html a00362_source.html a00365.html a00365.js a00365_source.html a00368.html a00368_source.html a00371_source.html a00374.html a00374.js a00374_source.html a00377.html a00377_source.html a00380.html a00380.js a00380_source.html a00383.html a00383.js a00383_source.html a00386_source.html a00389.html a00389.js a00389_source.html a00392.html a00392_source.html a00395_source.html a00398_source.html a00401.html a00401_source.html a00404.html a00404.js a00404_source.html a00407.html a00407.js a00407_source.html a00410.html a00410.js a00410_source.html a00413.html a00413.js a00413_source.html a00416.html a00416_source.html a00419.html a00419.js a00419_source.html a00422.html a00422.js a00422_source.html a00425.html a00425.js a00425_source.html a00428.html a00428.js a00428_source.html a00431.html a00431.js a00431_source.html a00434.html a00434.js a00434_source.html a00437.html a00437.js a00437_source.html a00440.html a00440.js a00440_source.html a00443.html a00443.js a00443_source.html a00446.html a00446.js a00446_source.html a00449.html a00449.js a00449_source.html a00452.html a00452.js a00452_source.html a00455.html a00455.js a00455_source.html a00458_source.html a00461_source.html a00464_source.html a00467_source.html a00470_source.html a00473_source.html a00476.html a00476_source.html a00479_source.html a00482.html a00482.js a00482_source.html a00485.html a00485.js a00485_source.html a00488_source.html a00491.html a00491.js a00491_source.html a00494.html a00494.js a00494_source.html a00497.html a00497.js a00497_source.html a00500_source.html a00503.html a00503.js a00503_source.html a00506.html a00506.js a00506_source.html a00509.html a00509.js a00509_source.html a00512.html a00512.js a00512_source.html a00515.html a00515_source.html a00518.html a00518.js a00518_source.html a00521.html a00521.js a00521_source.html a00524_source.html a00527.html a00527.js a00527_source.html a00530.html a00530_source.html a00533_source.html a00536.html a00536.js a00536_source.html a00539.html a00539_source.html a00542_source.html a00545.html a00545_source.html a00548.html a00548.js a00548_source.html a00551.html a00551.js a00551_source.html a00554.html a00554_source.html a00557.html a00557.js a00557_source.html a00560_source.html a00563.html a00563_source.html a00566.html a00566.js a00566_source.html a00569.html a00569.js a00569_source.html a00572.html a00572.js a00572_source.html a00575.html a00575.js a00575_source.html a00578.html a00578.js a00578_source.html a00581.html a00581.js a00581_source.html a00584.html a00584.js a00584_source.html a00587.html a00587.js a00587_source.html a00590.html a00590_source.html a00593.html a00593.js a00593_source.html a00596.html a00596.js a00596_source.html a00599.html a00599_source.html a00602.html a00602.js a00602_source.html a00605.html a00605.js a00605_source.html a00608.html a00608_source.html a00611.html a00611_source.html a00614.html a00614.js a00614_source.html a00617.html a00617_source.html a00620.html a00620_source.html a00623.html a00623.js a00623_source.html a00626_source.html a00629_source.html a00632.html a00632.js a00632_source.html a00635.html a00635.js a00635_source.html a00638.html a00638.js a00638_source.html a00641.html a00641_source.html a00644.html a00644.js a00644_source.html a00647.html a00647.js a00647_source.html a00650.html a00650.js a00650_source.html a00653.html a00653_source.html a00656.html a00656.js a00656_source.html a00659.html a00659.js a00659_source.html a00662.html a00662.js a00662_source.html a00665_source.html a00668.html a00668_source.html a00671.html a00671.js a00671_source.html a00674.html a00674.js a00674_source.html a00677.html a00677_source.html a00680.html a00680.js a00680_source.html a00683.html a00683.js a00683_source.html a00686.html a00686.js a00686_source.html a00689.html a00689_source.html a00692.html a00692_source.html a00695.html a00695.js a00695_source.html a00698.html a00698.js a00698_source.html a00701.html a00701_source.html a00704.html a00704.js a00704_source.html a00707.html a00707.js a00707_source.html a00710.html a00710.js a00710_source.html a00713.html a00713.js a00713_source.html a00716.html a00716.js a00716_source.html a00719.html a00719.js a00719_source.html a00722.html a00722.js a00722_source.html a00725.html a00725.js a00725_source.html a00728.html a00728.js a00728_source.html a00731.html a00731_source.html a00734.html a00734.js a00734_source.html a00737.html a00737.js a00737_source.html a00740.html a00740.js a00740_source.html a00743_source.html a00746.html a00746.js a00746_source.html a00749.html a00749.js a00749_source.html a00752.html a00752.js a00752_source.html a00755.html a00755_source.html a00758.html a00758_source.html a00761.html a00761_source.html a00764_source.html a00767.html a00767_source.html a00770.html a00770.js a00770_source.html a00773.html a00773_source.html a00784.html a00784.js a00785.html a00785.js a00786.html a00786.js a00787.html a00787.js a00788.html a00788.js a00789.html a00789.js a00790.html a00791.html a00791.js a00792.html a00792.js a00793.html a00793.js a00794.html a00794.js a00795.html a00795.js a00796.html a00796.js a00797.html a00797.js a00798.html a00798.js a00799.html a00799.js a00800.html a00801.html a00801.js a00802.html a00802.js a00803.html a00804.html a00805.html a00806.html a00806.js a00807.html a00807.js a00808.html a00808.js a00809.html a00809.js a00810.html a00810.js a00811.html a00811.js a00812.html a00812.js a00813.html a00813.js a00814.html a00814.js a00815.html a00816.html a00817.html a00817.js a00818.html a00818.js a00819.html a00819.js a00820.html a00820.js a00821.html a00821.js a00822.html a00822.js a00823.html a00823.js a00824.html a00824.js a00825.html a00825.js a00826.html a00826.js a00827.html a00827.js a00828.html a00828.js a00829.html a00829.js a00830.html a00830.js a00831.html a00831.js a00832.html a00832.js a00833.html a00833.js a00834.html a00834.js a00835.html a00835.js a00836.html a00836.js a00837.html a00837.js a00838.html a00838.js a00839.html a00839.js a00840.html a00840.js a00841.html a00841.js a00842.html a00842.js a00843.html a00843.js a00844.html a00844.js a00845.html a00845.js a00846.html a00846.js a00847.html a00847.js a00848.html a00848.js a00849.html a00849.js a00850.html a00850.js a00851.html a00851.js a00852.html a00852.js a00853.html a00853.js a00854.html a00854.js a00855.html a00855.js a00856.html a00856.js a00857.html a00857.js a00858.html a00858.js a00859.html a00859.js a00860.html a00860.js a00861.html a00861.js a00862.html a00862.js a00863.html a00863.js a00864.html a00864.js a00865.html a00865.js a00866.html a00866.js a00867.html a00867.js a00868.html a00868.js a00869.html a00869.js a00870.html a00870.js a00871.html a00871.js a00872.html a00872.js a00873.html a00873.js a00874.html a00874.js a00875.html a00875.js a00876.html a00876.js a00877.html a00877.js a00878.html a00878.js a00879.html a00879.js a00880.html a00880.js a00881.html a00881.js a00882.html a00882.js a00883.html a00883.js a00884.html a00884.js a00885.html a00885.js a00886.html a00886.js a00887.html a00887.js a00888.html a00888.js a00889.html a00889.js a00890.html a00890.js a00891.html a00891.js a00892.html a00892.js a00893.html a00893.js a00894.html a00894.js a00895.html a00895.js a00896.html a00896.js a00897.html a00897.js a00898.html a00898.js a00899.html a00899.js a00900.html a00900.js a00901.html a00901.js a00902.html a00902.js a00903.html a00903.js a00904.html a00904.js a00905.html a00906.html a00906.js a00907.html a00907.js a00908.html a00908.js a00909.html a00909.js a00910.html a00910.js a00911.html a00911.js a00912.html a00912.js a00913.html a00913.js a00914.html a00914.js a00915.html a00915.js a00916.html a00917.html a00917.js a00918.html a00918.js a00919.html a00919.js a00920.html a00920.js a00921.html a00921.js a00922.html a00922.js a00923.html a00924.html a00924.js a00925.html a00925.js a00926.html a00926.js a00927.html a00927.js a00928.html a00928.js a00929.html a00929.js a00930.html a00930.js a00931.html a00931.js a00932.html a00932.js a00933.html a00933.js a00934.html a00934.js a00935.html a00935.js a00936.html a00936.js a00937.html a00937.js a00938.html a00938.js a00939.html a00939.js a00940.html a00940.js a00941.html a00941.js a00942.html a00942.js a00943.html a00943.js a00944.html a00945.html a00945.js a00946.html a00946.js a00947.html a00947.js a00948.html a00948.js a00949.html a00949.js a00950.html a00951.html a00952.html a00953.html a00954.html a00954.js a00955.html a00955.js a00956.html a00956.js a00957.html a00957.js a00958.html a00958.js a00959.html a00959.js a00960.html a00960.js a00961.html a00961.js a00962.html a00962.js a00963.html a00963.js a00964.html a00964.js a00965.html a00965.js a00966.html a00966.js a00967.html a00967.js a00968.html a00968.js a00969.html a00969.js a00970.html a00970.js a00971.html a00971.js a00972.html a00972.js a00973.html a00973.js a00974.html a00974.js a00975.html a00975.js a00976.html a00976.js a00977.html a00977.js a00978.html a00978.js a00979.html a00979.js a00980.html a00980.js a00981.html a00982.html a00982.js a00983.html a00983.js a00984.html a00984.js a00985.html a00985.js a00986.html a00986.js a00987.html a00987.js a00988.html a00988.js a00989.html a00989.js a00990.html a00990.js a00991.html a00991.js a00992.html a00992.js a00993.html a00993.js a00994.html a00994.js a00995.html a00995.js a00996.html a00996.js a00997.html a00997.js a00998.html a00998.js a00999.html a00999.js a01000.html a01000.js a01001.html a01001.js a01002.html a01002.js a01003.html a01003.js a01004.html a01004.js a01005.html a01005.js a01006.html a01006.js a01007.html a01007.js a01008.html a01008.js a01009.html a01009.js a01010.html a01010.js a01011.html a01011.js a01012.html a01012.js a01013.html a01013.js a01014.html a01014.js a01015.html a01015.js a01016.html a01016.js a01017.html a01017.js a01018.html a01018.js a01019.html a01019.js a01020.html a01020.js a01021.html a01021.js a01022.html a01022.js a01023.html a01023.js a01024.html a01024.js a01025.html a01025.js a01026.html a01026.js a01027.html a01027.js a01028.html a01028.js a01029.html a01029.js a01030.html a01030.js a01031.html a01032.html a01033.html a01034.html a01035.html a01035.js a01036.html a01036.js a01037.html a01037.js a01038.html a01038.js a01039.html a01039.js a01040.html a01040.js a01041.html a01042.html a01043.html a01044.html a01045.html a01046.html a01047.html a01048.html a01049.html a01050.html a01051.html a01052.html a01053.html a01054.html a01055.html a01056.html a01057.html a01058.html a01059.html a01060.html a01061.html a01062.html a01063.html a01064.html a01065.html a01066.html a01067.html a01068.html a01069.html a01070.html a01071.html a01072.html a01073.html a01073.js a01074.html a01074.js a01075.html a01076.html a01076.js a01077.html a01077.js a01078.html a01078.js a01079.html a01079.js a01080.html a01080.js a01081.html a01081.js a01082.html a01082.js a01083.html a01083.js a01084.html a01084.js a01085.html a01085.js a01086.html a01086.js a01087.html a01087.js a01088.html a01088.js a01089.html a01089.js a01090.html a01090.js a01091.html a01091.js a01092.html a01092.js a01096.html a01100.html a01104.html a01108.html a01112.html a01116.html a01120.html a01124.html a01128.html a01128.js a01132.html a01132.js a01136.html a01136.js a01140.html a01140.js a01144.html a01144.js a01148.html a01148.js a01160.html a01160.js a01172.html a01172.js a01184.html a01184.js a01196.html a01196.js a01208.html a01208.js a01220.html a01220.js a01232.html a01232.js a01244.html a01244.js a01256.html a01256.js a01268.html a01268.js a01280.html a01280.js a01292.html a01292.js a01304.html a01304.js a01316.html a01316.js a01328.html a01328.js a01340.html a01340.js a01352.html a01352.js a01364.html a01364.js a01376.html a01376.js a01388.html a01388.js a01392.html a01392.js a01396.html a01396.js a01400.html a01400.js a01404.html a01404.js a01408.html a01408.js a01409.html a01410.html a01411.html a01412.html a01413.html a01414.html a01415.html a01416.html a01417.html a01418.html a01419.html a01420.html a01421.html a01422.html a01423.html a01424.html a01425.html a01426.html a01428.html a01429.html a01430.html a01431.html a01432.html a01433.html a01434.html a01435.html a01436.html a01437.html a01438.html a01439.html a01440.html a01441.html a01443.html a01444.html a01445.html a01446.html a01447.html a01448.html a01449.html a01450.html a01451.html a01452.html a01453.html a01454.html annotated.html annotated_dup.js bc_s.png bc_sd.png classes.html closed.png dir_12400abb43c7917b01bd96c487cb12de.html dir_12400abb43c7917b01bd96c487cb12de.js dir_19add577f82c4aaf210a9fd97c7a47f1.html dir_19add577f82c4aaf210a9fd97c7a47f1.js dir_1fe5caa4c5890695a90a9eb5e463e983.html dir_1fe5caa4c5890695a90a9eb5e463e983.js dir_2aff7cd4a4e6a56293c1f9560b041fca.html dir_2aff7cd4a4e6a56293c1f9560b041fca.js dir_2d1263dd8b38fa03b781080dc54fd771.html dir_2d1263dd8b38fa03b781080dc54fd771.js dir_463ab23b7327290c59cd9a16d7215ca9.html dir_463ab23b7327290c59cd9a16d7215ca9.js dir_54b7ca9be566f6de17f16c7107c46b4d.html dir_54b7ca9be566f6de17f16c7107c46b4d.js dir_6121e1b4d335b01221b4693385b05c22.html dir_63890e6bafaa4357ecca65ab9e331873.html dir_63890e6bafaa4357ecca65ab9e331873.js dir_8c5a2ec5543af745a8e432a8325d77ac.html dir_8c5a2ec5543af745a8e432a8325d77ac.js dir_9f351d46ce3cc29445a41dc3a31e6919.html dir_ad26a86a6d815bacd5a106ab758d9662.html dir_b4bd4a875ee6f7611277327ae1a6a06e.html dir_b4bd4a875ee6f7611277327ae1a6a06e.js dir_d582aeb6b44135bbd71fd91c7f015d7e.html dir_d582aeb6b44135bbd71fd91c7f015d7e.js dir_db8d8f8d238d2df22c664e83baf75094.html dir_db8d8f8d238d2df22c664e83baf75094.js dir_df4457f3f3602a280fc3ec17d0f9e73a.html dir_e4a4744ae972a7de7a621104b51a3395.html dir_e4a4744ae972a7de7a621104b51a3395.js dir_e51b04cce781b03dff199f2b6a763ac7.html dir_e51b04cce781b03dff199f2b6a763ac7.js dir_eb398801e23de8ece7ce18e317906fdc.html dir_eb398801e23de8ece7ce18e317906fdc.js dir_fe823e39d359c4a0704a03b7c2618f6f.html dir_fe823e39d359c4a0704a03b7c2618f6f.js doc.svg docd.svg doxygen.css doxygen.svg dynsections.js examples.html examples.js files.html files_dup.js folderclosed.svg folderclosedd.svg folderopen.svg folderopend.svg functions.html functions_a.html functions_b.html functions_c.html functions_d.html functions_dup.js functions_e.html functions_f.html functions_g.html functions_h.html functions_i.html functions_k.html functions_l.html functions_m.html functions_o.html functions_p.html functions_r.html functions_s.html functions_t.html functions_u.html functions_v.html functions_vars.html functions_vars.js functions_vars_a.html functions_vars_b.html functions_vars_c.html functions_vars_d.html functions_vars_e.html functions_vars_f.html functions_vars_g.html functions_vars_h.html functions_vars_i.html functions_vars_k.html functions_vars_l.html functions_vars_m.html functions_vars_o.html functions_vars_p.html functions_vars_r.html functions_vars_s.html functions_vars_t.html functions_vars_u.html functions_vars_v.html functions_vars_w.html functions_w.html globals.html globals_d.html globals_defs.html globals_defs.js globals_defs_m.html globals_defs_r.html globals_defs_u.html globals_dup.js globals_e.html globals_func.html globals_m.html globals_r.html globals_s.html globals_type.html globals_u.html globals_vars.html globals_vars.js globals_vars_d.html globals_vars_e.html globals_vars_m.html globals_vars_r.html globals_vars_s.html index.html index.js jquery.js modules.html modules.js nav_f.png nav_fd.png nav_g.png nav_h.png nav_hd.png navtree.css navtree.js navtreedata.js navtreeindex0.js navtreeindex1.js navtreeindex10.js navtreeindex2.js navtreeindex3.js navtreeindex4.js navtreeindex5.js navtreeindex6.js navtreeindex7.js navtreeindex8.js navtreeindex9.js open.png pages.html resize.js splitbar.png splitbard.png sync_off.png sync_on.png tab_a.png tab_ad.png tab_b.png tab_bd.png tab_h.png tab_hd.png tab_s.png tab_sd.png tabs.css
  group component/els_pkc/doc/rw61x/html/search
    ../../../../../../components/els_pkc/doc/rw61x/html/search/: all_0.js all_1.js all_10.js all_11.js all_12.js all_13.js all_14.js all_2.js all_3.js all_4.js all_5.js all_6.js all_7.js all_8.js all_9.js all_a.js all_b.js all_c.js all_d.js all_e.js all_f.js classes_0.js classes_1.js classes_2.js close.svg defines_0.js defines_1.js files_0.js files_1.js functions_0.js groups_0.js groups_1.js groups_2.js groups_3.js groups_4.js groups_5.js groups_6.js groups_7.js groups_8.js groups_9.js groups_a.js groups_b.js groups_c.js groups_d.js mag.svg mag_d.svg mag_sel.svg mag_seld.svg pages_0.js pages_1.js search.css search.js searchdata.js typedefs_0.js variables_0.js variables_1.js variables_10.js variables_11.js variables_12.js variables_13.js variables_14.js variables_2.js variables_3.js variables_4.js variables_5.js variables_6.js variables_7.js variables_8.js variables_9.js variables_a.js variables_b.js variables_c.js variables_d.js variables_e.js variables_f.js
  group component/els_pkc/static_library/rw61x
    ../../../../../../components/els_pkc/static_library/rw61x/: libclns.a libclns.a.libsize libclns.a.objsize
  group component/els_pkc/src/comps/mcuxClAead/src
    ../../../../../../components/els_pkc/src/comps/mcuxClAead/src/: mcuxClAead.c
  group component/els_pkc/src/comps/mcuxClAead/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClAead/inc/: mcuxClAead.h mcuxClAead_Constants.h mcuxClAead_Functions.h mcuxClAead_Types.h
  group component/els_pkc/src/comps/mcuxClAead/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClAead/inc/internal/: mcuxClAead_Ctx.h mcuxClAead_Descriptor.h mcuxClAead_Internal_Functions.h
  group component/els_pkc/src/comps/mcuxClAeadModes/src
    ../../../../../../components/els_pkc/src/comps/mcuxClAeadModes/src/: mcuxClAeadModes_Els_AesCcm.c mcuxClAeadModes_Els_AesCcmEngine.c mcuxClAeadModes_Els_AesGcm.c mcuxClAeadModes_Els_AesGcmEngine.c mcuxClAeadModes_Els_Modes.c mcuxClAeadModes_Els_Multipart.c mcuxClAeadModes_Els_Oneshot.c
  group component/els_pkc/src/comps/mcuxClAeadModes/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClAeadModes/inc/: mcuxClAeadModes.h mcuxClAeadModes_Modes.h
  group component/els_pkc/src/comps/mcuxClAeadModes/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClAeadModes/inc/internal/: mcuxClAeadModes_Common.h mcuxClAeadModes_Common_Constants.h mcuxClAeadModes_Common_Functions.h mcuxClAeadModes_Els_Algorithms.h mcuxClAeadModes_Els_Functions.h mcuxClAeadModes_Els_Types.h
  group component/els_pkc/src/comps/mcuxClAes/src
    ../../../../../../components/els_pkc/src/comps/mcuxClAes/src/: mcuxClAes_KeyTypes.c
  group component/els_pkc/src/comps/mcuxClAes/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClAes/inc/: mcuxClAes.h mcuxClAes_Constants.h mcuxClAes_KeyTypes.h mcuxClAes_Types.h
  group component/els_pkc/src/comps/mcuxClAes/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClAes/inc/internal/: mcuxClAes_Ctx.h mcuxClAes_Internal_Constants.h mcuxClAes_Internal_Functions.h mcuxClAes_Wa.h
  group component/els_pkc/src/comps/mcuxClBuffer/src
    ../../../../../../components/els_pkc/src/comps/mcuxClBuffer/src/: mcuxClBuffer.c
  group component/els_pkc/src/comps/mcuxClBuffer/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClBuffer/inc/: mcuxClBuffer.h mcuxClBuffer_Cfg.h mcuxClBuffer_Constants.h mcuxClBuffer_Impl.h mcuxClBuffer_Pointer.h
  group component/els_pkc/src/comps/mcuxClBuffer/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClBuffer/inc/internal/: mcuxClBuffer_Internal.h mcuxClBuffer_Internal_Pointer.h
  group component/els_pkc/src/comps/mcuxClCipher/src
    ../../../../../../components/els_pkc/src/comps/mcuxClCipher/src/: mcuxClCipher.c
  group component/els_pkc/src/comps/mcuxClCipher/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClCipher/inc/: mcuxClCipher.h mcuxClCipher_Constants.h mcuxClCipher_Functions.h mcuxClCipher_Types.h
  group component/els_pkc/src/comps/mcuxClCipher/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClCipher/inc/internal/: mcuxClCipher_Internal.h mcuxClCipher_Internal_Constants.h mcuxClCipher_Internal_Functions.h mcuxClCipher_Internal_Types.h
  group component/els_pkc/src/comps/mcuxClCipherModes/src
    ../../../../../../components/els_pkc/src/comps/mcuxClCipherModes/src/: mcuxClCipherModes_Common_Helper.c mcuxClCipherModes_Crypt_Els_Modes.c mcuxClCipherModes_Els_Aes.c mcuxClCipherModes_Els_AesEngine.c mcuxClCipherModes_Els_Aes_Internal.c
  group component/els_pkc/src/comps/mcuxClCipherModes/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClCipherModes/inc/: mcuxClCipherModes.h mcuxClCipherModes_Modes.h
  group component/els_pkc/src/comps/mcuxClCipherModes/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClCipherModes/inc/internal/: mcuxClCipherModes_Common.h mcuxClCipherModes_Common_Constants.h mcuxClCipherModes_Common_Helper.h mcuxClCipherModes_Common_Wa.h mcuxClCipherModes_Els_Algorithms.h mcuxClCipherModes_Els_Functions.h mcuxClCipherModes_Els_Types.h
  group component/els_pkc/src/comps/mcuxClCore/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClCore/inc/: mcuxClCore_Examples.h mcuxClCore_FunctionIdentifiers.h mcuxClCore_Macros.h mcuxClCore_Platform.h mcuxClCore_Toolchain.h
  group component/els_pkc/src/comps/mcuxClEcc/src
    ../../../../../../components/els_pkc/src/comps/mcuxClEcc/src/: mcuxClEcc_Constants.c mcuxClEcc_ECDSA_GenerateProtocolDescriptor.c mcuxClEcc_ECDSA_Internal_BlindedSecretKeyGen.c mcuxClEcc_ECDSA_Internal_BlindedSecretKeyGen_FUP.c mcuxClEcc_EdDSA_GenerateKeyPair.c mcuxClEcc_EdDSA_GenerateKeyPair_FUP.c mcuxClEcc_EdDSA_GenerateSignature.c mcuxClEcc_EdDSA_GenerateSignatureMode.c mcuxClEcc_EdDSA_GenerateSignature_FUP.c mcuxClEcc_EdDSA_InitPrivKeyInputMode.c mcuxClEcc_EdDSA_Internal_CalcHashModN.c mcuxClEcc_EdDSA_Internal_CalcHashModN_FUP.c mcuxClEcc_EdDSA_Internal_DecodePoint_Ed25519.c mcuxClEcc_EdDSA_Internal_DecodePoint_FUP.c mcuxClEcc_EdDSA_Internal_EncodePoint.c mcuxClEcc_EdDSA_Internal_SetupEnvironment.c mcuxClEcc_EdDSA_Internal_SignatureMechanisms.c mcuxClEcc_EdDSA_VerifySignature.c mcuxClEcc_Internal_BlindedScalarMult.c mcuxClEcc_Internal_Convert_FUP.c mcuxClEcc_Internal_GenerateMultiplicativeBlinding.c mcuxClEcc_Internal_InterleaveScalar.c mcuxClEcc_Internal_InterleaveTwoScalars.c mcuxClEcc_Internal_Interleave_FUP.c mcuxClEcc_Internal_PointComparison_FUP.c mcuxClEcc_Internal_RecodeAndReorderScalar.c mcuxClEcc_Internal_SetupEnvironment.c mcuxClEcc_Internal_SetupEnvironment_FUP.c mcuxClEcc_Internal_Types.c mcuxClEcc_KeyTypes.c mcuxClEcc_MontDH_GenerateKeyPair.c mcuxClEcc_MontDH_KeyAgreement.c mcuxClEcc_Mont_Internal_DhSetupEnvironment.c mcuxClEcc_Mont_Internal_MontDhX.c mcuxClEcc_Mont_Internal_MontDhX_FUP.c mcuxClEcc_Mont_Internal_SecureScalarMult_XZMontLadder.c mcuxClEcc_Mont_Internal_SecureScalarMult_XZMontLadder_FUP.c mcuxClEcc_TwEd_Internal_FixScalarMult.c mcuxClEcc_TwEd_Internal_PlainFixScalarMult25519.c mcuxClEcc_TwEd_Internal_PlainPtrSelectComb.c mcuxClEcc_TwEd_Internal_PlainPtrSelectML.c mcuxClEcc_TwEd_Internal_PlainVarScalarMult.c mcuxClEcc_TwEd_Internal_PointArithmetic.c mcuxClEcc_TwEd_Internal_PointArithmetic_FUP.c mcuxClEcc_TwEd_Internal_PointArithmeticEd25519.c mcuxClEcc_TwEd_Internal_PointArithmeticEd25519_FUP.c mcuxClEcc_TwEd_Internal_PointSubtraction_FUP.c mcuxClEcc_TwEd_Internal_PointValidation_FUP.c mcuxClEcc_TwEd_Internal_PrecPointImportAndValidate.c mcuxClEcc_TwEd_Internal_VarScalarMult.c mcuxClEcc_TwEd_Internal_VarScalarMult_FUP.c mcuxClEcc_WeierECC_Internal_BlindedSecretKeyGen.c mcuxClEcc_WeierECC_Internal_BlindedSecretKeyGen_FUP.c mcuxClEcc_WeierECC_Internal_GenerateKeyPair.c mcuxClEcc_WeierECC_Internal_SetupEnvironment.c mcuxClEcc_Weier_Internal_ConvertPoint_FUP.c mcuxClEcc_Weier_Internal_FUP.c mcuxClEcc_Weier_Internal_PointArithmetic.c mcuxClEcc_Weier_Internal_PointArithmetic_FUP.c mcuxClEcc_Weier_Internal_PointCheck.c mcuxClEcc_Weier_Internal_PointCheck_FUP.c mcuxClEcc_Weier_Internal_PointMult.c mcuxClEcc_Weier_Internal_SecurePointMult_CoZMontLadder.c mcuxClEcc_Weier_Internal_SecurePointMult_CoZMontLadder_FUP.c mcuxClEcc_Weier_Internal_SetupEnvironment.c mcuxClEcc_Weier_KeyGen.c mcuxClEcc_Weier_KeyGen_FUP.c mcuxClEcc_Weier_PointMult.c mcuxClEcc_Weier_PointMult_FUP.c mcuxClEcc_Weier_Sign.c mcuxClEcc_Weier_Sign_FUP.c mcuxClEcc_Weier_Verify.c mcuxClEcc_Weier_Verify_FUP.c
  group component/els_pkc/src/comps/mcuxClEcc/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClEcc/inc/: mcuxClEcc.h mcuxClEcc_Constants.h mcuxClEcc_EdDSA_GenerateKeyPair_FUP.h mcuxClEcc_EdDSA_GenerateSignature_FUP.h mcuxClEcc_EdDSA_Internal_CalcHashModN_FUP.h mcuxClEcc_EdDSA_Internal_DecodePoint_FUP.h mcuxClEcc_Functions.h mcuxClEcc_Internal_Convert_FUP.h mcuxClEcc_Internal_Interleave_FUP.h mcuxClEcc_Internal_PointComparison_FUP.h mcuxClEcc_Internal_SetupEnvironment_FUP.h mcuxClEcc_KeyTypes.h mcuxClEcc_Mont_Internal_MontDhX_FUP.h mcuxClEcc_Mont_Internal_SecureScalarMult_XZMontLadder_FUP.h mcuxClEcc_TwEd_Internal_PointArithmeticEd25519_FUP.h mcuxClEcc_TwEd_Internal_PointSubtraction_FUP.h mcuxClEcc_TwEd_Internal_PointArithmetic_FUP.h mcuxClEcc_TwEd_Internal_PointValidation_FUP.h mcuxClEcc_TwEd_Internal_VarScalarMult_FUP.h mcuxClEcc_Types.h mcuxClEcc_WeierECC_Internal_BlindedSecretKeyGen_FUP.h mcuxClEcc_Weier_Internal_ConvertPoint_FUP.h mcuxClEcc_Weier_Internal_FUP.h mcuxClEcc_Weier_Internal_PointArithmetic_FUP.h mcuxClEcc_Weier_Internal_PointCheck_FUP.h mcuxClEcc_Weier_Internal_SecurePointMult_CoZMontLadder_FUP.h mcuxClEcc_Weier_KeyGen_FUP.h mcuxClEcc_Weier_PointMult_FUP.h mcuxClEcc_Weier_Sign_FUP.h mcuxClEcc_Weier_Verify_FUP.h
  group component/els_pkc/src/comps/mcuxClEcc/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClEcc/inc/internal/: mcuxClEcc_ECDH_Internal.h mcuxClEcc_ECDSA_Internal.h mcuxClEcc_ECDSA_Internal_FUP.h mcuxClEcc_EdDSA_Internal.h mcuxClEcc_EdDSA_Internal_FUP.h mcuxClEcc_EdDSA_Internal_Hash.h mcuxClEcc_Internal.h mcuxClEcc_Internal_FUP.h mcuxClEcc_Internal_PkcWaLayout.h mcuxClEcc_Internal_Random.h mcuxClEcc_Internal_SecurePointSelect.h mcuxClEcc_Internal_UPTRT_access.h mcuxClEcc_Mont_Internal.h mcuxClEcc_Mont_Internal_FUP.h mcuxClEcc_Mont_Internal_PkcWaLayout.h mcuxClEcc_TwEd_Internal.h mcuxClEcc_TwEd_Internal_FUP.h mcuxClEcc_TwEd_Internal_PkcWaLayout.h mcuxClEcc_WeierEcc_KeyGenerate_Internal.h mcuxClEcc_Weier_Internal.h mcuxClEcc_Weier_Internal_FP.h mcuxClEcc_Weier_Internal_FUP.h mcuxClEcc_Weier_Internal_PkcWaLayout.h
  group component/els_pkc/src/comps/mcuxClEls/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClEls/inc/: mcuxClEls.h mcuxClEls_Aead.h mcuxClEls_Cipher.h mcuxClEls_Cmac.h mcuxClEls_Crc.h mcuxClEls_Ecc.h mcuxClEls_Hash.h mcuxClEls_Hmac.h mcuxClEls_Kdf.h mcuxClEls_mapping.h mcuxClEls_Rng.h mcuxClEls_Types.h mcuxClEls_KeyManagement.h mcuxClEls_Common.h mcuxClEls_GlitchDetector.h
  group component/els_pkc/src/comps/mcuxClEls/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClEls/inc/internal/: mcuxClEls_Internal.h mcuxClEls_Internal_mapping.h mcuxClEls_SfrAccess.h mcuxClEls_Internal_Common.h
  group component/els_pkc/src/comps/mcuxClEls/src
    ../../../../../../components/els_pkc/src/comps/mcuxClEls/src/: mcuxClEls_Common.c mcuxClEls_GlitchDetector.c mcuxClEls_Aead.c mcuxClEls_Cipher.c mcuxClEls_Cmac.c mcuxClEls_Ecc.c mcuxClEls_Hash.c mcuxClEls_Hmac.c mcuxClEls_Kdf.c mcuxClEls_Rng.c mcuxClEls_KeyManagement.c
  group component/els_pkc/src/comps/mcuxClHash/src
    ../../../../../../components/els_pkc/src/comps/mcuxClHash/src/: mcuxClHash_api_multipart_common.c mcuxClHash_api_multipart_compute.c mcuxClHash_api_oneshot_compute.c mcuxClHash_Internal.c
  group component/els_pkc/src/comps/mcuxClHash/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClHash/inc/: mcuxClHash.h mcuxClHash_Constants.h mcuxClHash_Functions.h mcuxClHash_Types.h
  group component/els_pkc/src/comps/mcuxClHash/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClHash/inc/internal/: mcuxClHash_Internal.h mcuxClHash_Internal_Memory.h
  group component/els_pkc/src/comps/mcuxClHashModes/src
    ../../../../../../components/els_pkc/src/comps/mcuxClHashModes/src/: mcuxClHashModes_Core_c_sha1.c mcuxClHashModes_Core_els_sha2.c mcuxClHashModes_Internal_c_sha1.c mcuxClHashModes_Internal_els_sha2.c
  group component/els_pkc/src/comps/mcuxClHashModes/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClHashModes/inc/: mcuxClHashModes.h mcuxClHashModes_Algorithms.h mcuxClHashModes_Constants.h mcuxClHashModes_Functions.h
  group component/els_pkc/src/comps/mcuxClHashModes/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClHashModes/inc/internal/: mcuxClHashModes_Core_c_sha1.h mcuxClHashModes_Core_els_sha2.h mcuxClHashModes_Internal.h mcuxClHashModes_Internal_els_sha2.h mcuxClHashModes_Internal_Memory.h
  group component/els_pkc/src/comps/mcuxClHmac/src
    ../../../../../../components/els_pkc/src/comps/mcuxClHmac/src/: mcuxClHmac_Els.c mcuxClHmac_Functions.c mcuxClHmac_Helper.c mcuxClHmac_KeyTypes.c mcuxClHmac_Modes.c mcuxClHmac_Sw.c
  group component/els_pkc/src/comps/mcuxClHmac/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClHmac/inc/: mcuxClHmac.h mcuxClHmac_Constants.h mcuxClHmac_Functions.h mcuxClHmac_KeyTypes.h mcuxClHmac_Modes.h
  group component/els_pkc/src/comps/mcuxClHmac/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClHmac/inc/internal/: mcuxClHmac_Core_Functions_Els.h mcuxClHmac_Core_Functions_Sw.h mcuxClHmac_Internal_Functions.h mcuxClHmac_Internal_Memory.h mcuxClHmac_Internal_Types.h
  group component/els_pkc/src/comps/mcuxClKey/src
    ../../../../../../components/els_pkc/src/comps/mcuxClKey/src/: mcuxClKey.c mcuxClKey_Protection.c
  group component/els_pkc/src/comps/mcuxClKey/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClKey/inc/: mcuxClKey.h mcuxClKey_Constants.h mcuxClKey_Functions.h mcuxClKey_ProtectionMechanisms.h mcuxClKey_Types.h
  group component/els_pkc/src/comps/mcuxClKey/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClKey/inc/internal/: mcuxClKey_Functions_Internal.h mcuxClKey_Internal.h mcuxClKey_Protection_Internal.h mcuxClKey_Types_Internal.h
  group component/els_pkc/src/comps/mcuxClMac/src
    ../../../../../../components/els_pkc/src/comps/mcuxClMac/src/: mcuxClMac.c
  group component/els_pkc/src/comps/mcuxClMac/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClMac/inc/: mcuxClMac.h mcuxClMac_Constants.h mcuxClMac_Functions.h mcuxClMac_Types.h
  group component/els_pkc/src/comps/mcuxClMac/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClMac/inc/internal/: mcuxClMac_Ctx.h mcuxClMac_Internal_Constants.h mcuxClMac_Internal_Functions.h mcuxClMac_Internal_Types.h
  group component/els_pkc/src/comps/mcuxClMacModes/src
    ../../../../../../components/els_pkc/src/comps/mcuxClMacModes/src/: mcuxClMacModes_Common.c mcuxClMacModes_Common_Modes.c mcuxClMacModes_Els_Cbcmac.c mcuxClMacModes_Els_Cmac.c mcuxClMacModes_Els_Functions.c
  group component/els_pkc/src/comps/mcuxClMacModes/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClMacModes/inc/: mcuxClMacModes.h mcuxClMacModes_Constants.h mcuxClMacModes_Functions.h mcuxClMacModes_Modes.h
  group component/els_pkc/src/comps/mcuxClMacModes/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClMacModes/inc/internal/: mcuxClMacModes_Common_Algorithms.h mcuxClMacModes_Common_Constants.h mcuxClMacModes_Common_Functions.h mcuxClMacModes_Common_Memory.h mcuxClMacModes_Common_Types.h mcuxClMacModes_Common_Wa.h mcuxClMacModes_Els_Cbcmac.h mcuxClMacModes_Els_Cmac.h mcuxClMacModes_Els_Ctx.h mcuxClMacModes_Els_Types.h
  group component/els_pkc/src/comps/mcuxClMath/src
    ../../../../../../components/els_pkc/src/comps/mcuxClMath/src/: mcuxClMath_ExactDivide.c mcuxClMath_ExactDivideOdd.c mcuxClMath_ExactDivideOdd_FUP.c mcuxClMath_ModExp_SqrMultL2R.c mcuxClMath_ModInv.c mcuxClMath_ModInv_FUP.c mcuxClMath_NDash.c mcuxClMath_NDash_FUP.c mcuxClMath_QDash.c mcuxClMath_QDash_FUP.c mcuxClMath_ReduceModEven.c mcuxClMath_SecModExp.c mcuxClMath_SecModExp_FUP.c mcuxClMath_Utils.c
  group component/els_pkc/src/comps/mcuxClMath/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClMath/inc/: mcuxClMath.h mcuxClMath_ExactDivideOdd_FUP.h mcuxClMath_Functions.h mcuxClMath_ModInv_FUP.h mcuxClMath_NDash_FUP.h mcuxClMath_QDash_FUP.h mcuxClMath_SecModExp_FUP.h mcuxClMath_Types.h
  group component/els_pkc/src/comps/mcuxClMath/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClMath/inc/internal/: mcuxClMath_ExactDivideOdd_FUP.h mcuxClMath_Internal_ExactDivideOdd.h mcuxClMath_Internal_ModInv.h mcuxClMath_Internal_NDash.h mcuxClMath_Internal_QDash.h mcuxClMath_Internal_SecModExp.h mcuxClMath_Internal_Utils.h mcuxClMath_ModInv_FUP.h mcuxClMath_NDash_FUP.h mcuxClMath_QDash_FUP.h mcuxClMath_SecModExp_FUP.h
  group component/els_pkc/src/comps/mcuxClMemory/src
    ../../../../../../components/els_pkc/src/comps/mcuxClMemory/src/: mcuxClMemory.c
  group component/els_pkc/src/comps/mcuxClMemory/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClMemory/inc/: mcuxClMemory.h mcuxClMemory_Clear.h mcuxClMemory_Constants.h mcuxClMemory_Copy.h mcuxClMemory_Copy_Reversed.h mcuxClMemory_Endianness.h mcuxClMemory_Set.h mcuxClMemory_Types.h mcuxClMemory_Xor.h
  group component/els_pkc/src/comps/mcuxClMemory/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClMemory/inc/internal/: mcuxClMemory_Internal.h
  group component/els_pkc/src/comps/mcuxCsslMemory/src
    ../../../../../../components/els_pkc/src/comps/mcuxCsslMemory/src/: mcuxCsslMemory_Clear.c mcuxCsslMemory_Compare.c mcuxCsslMemory_Copy.c mcuxCsslMemory_Set.c
  group component/els_pkc/src/comps/mcuxCsslMemory/inc
    ../../../../../../components/els_pkc/src/comps/mcuxCsslMemory/inc/: mcuxCsslMemory.h mcuxCsslMemory_Clear.h mcuxCsslMemory_Compare.h mcuxCsslMemory_Constants.h mcuxCsslMemory_Copy.h mcuxCsslMemory_Set.h mcuxCsslMemory_Types.h
  group component/els_pkc/src/comps/mcuxCsslMemory/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxCsslMemory/inc/internal/: mcuxCsslMemory_Internal_Compare_asm.h mcuxCsslMemory_Internal_Copy_asm.h
  group component/els_pkc/src/comps/mcuxClPadding/src
    ../../../../../../components/els_pkc/src/comps/mcuxClPadding/src/: mcuxClPadding.c
  group component/els_pkc/src/comps/mcuxClPadding/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClPadding/inc/: mcuxClPadding.h mcuxClPadding_Constants.h mcuxClPadding_Types.h
  group component/els_pkc/src/comps/mcuxClPadding/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClPadding/inc/internal/: mcuxClPadding_Functions_Internal.h mcuxClPadding_Internal.h mcuxClPadding_Types_Internal.h
  group component/els_pkc/src/comps/mcuxClPkc/src
    ../../../../../../components/els_pkc/src/comps/mcuxClPkc/src/: mcuxClPkc_Calculate.c mcuxClPkc_ImportExport.c mcuxClPkc_Initialize.c mcuxClPkc_UPTRT.c
  group component/els_pkc/src/comps/mcuxClPkc/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClPkc/inc/: mcuxClPkc.h mcuxClPkc_Functions.h mcuxClPkc_Types.h
  group component/els_pkc/src/comps/mcuxClPkc/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClPkc/inc/internal/: mcuxClPkc_FupMacros.h mcuxClPkc_ImportExport.h mcuxClPkc_Inline_Functions.h mcuxClPkc_Macros.h mcuxClPkc_Operations.h mcuxClPkc_Resource.h mcuxClPkc_SfrAccess.h
  group component/els_pkc/src/comps/mcuxClPrng/src
    ../../../../../../components/els_pkc/src/comps/mcuxClPrng/src/: mcuxClPrng_ELS.c
  group component/els_pkc/src/comps/mcuxClPrng/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClPrng/inc/internal/: mcuxClPrng_Internal.h mcuxClPrng_Internal_Constants.h mcuxClPrng_Internal_ELS.h mcuxClPrng_Internal_Functions.h mcuxClPrng_Internal_Types.h
  group component/els_pkc/src/comps/mcuxClPsaDriver/src
    ../../../../../../components/els_pkc/src/comps/mcuxClPsaDriver/src/: mcuxClPsaDriver_Aead.c mcuxClPsaDriver_Cipher.c mcuxClPsaDriver_DER_functions.c mcuxClPsaDriver_export_public_key.c mcuxClPsaDriver_generate_ecp_key.c mcuxClPsaDriver_Hash.c mcuxClPsaDriver_Key.c mcuxClPsaDriver_Mac.c mcuxClPsaDriver_Rsa.c mcuxClPsaDriver_Sign.c mcuxClPsaDriver_UpdateKeyStatus.c mcuxClPsaDriver_Verify.c
  group component/els_pkc/src/comps/mcuxClPsaDriver/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClPsaDriver/inc/: mcuxClPsaDriver.h mcuxClPsaDriver_Constants.h mcuxClPsaDriver_MemoryConsumption.h mcuxClPsaDriver_Oracle.h els_pkc_crypto_primitives.h els_pkc_crypto_composites.h
  group component/els_pkc/src/comps/mcuxClPsaDriver/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClPsaDriver/inc/internal/: mcuxClPsaDriver_ExternalMacroWrappers.h mcuxClPsaDriver_Functions.h mcuxClPsaDriver_Internal.h mcuxClPsaDriver_Types.h
  group component/els_pkc/src/comps/mcuxClRandom/src
    ../../../../../../components/els_pkc/src/comps/mcuxClRandom/src/: mcuxClRandom_DRBG.c mcuxClRandom_PRNG.c
  group component/els_pkc/src/comps/mcuxClRandom/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClRandom/inc/: mcuxClRandom.h mcuxClRandom_Constants.h mcuxClRandom_Functions.h mcuxClRandom_Types.h
  group component/els_pkc/src/comps/mcuxClRandom/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClRandom/inc/internal/: mcuxClRandom_Internal_Functions.h mcuxClRandom_Internal_Memory.h mcuxClRandom_Internal_Types.h
  group component/els_pkc/src/comps/mcuxClRandomModes/src
    ../../../../../../components/els_pkc/src/comps/mcuxClRandomModes/src/: mcuxClRandomModes_CtrDrbg_Els.c mcuxClRandomModes_ElsMode.c mcuxClRandomModes_PatchMode.c mcuxClRandomModes_TestMode.c mcuxClRandomModes_CtrDrbg.c mcuxClRandomModes_CtrDrbg_PrDisabled.c mcuxClRandomModes_NormalMode.c mcuxClRandomModes_PrDisabled.c
  group component/els_pkc/src/comps/mcuxClRandomModes/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClRandomModes/inc/: mcuxClRandomModes.h mcuxClRandomModes_Constants.h mcuxClRandomModes_Functions_PatchMode.h mcuxClRandomModes_Functions_TestMode.h
  group component/els_pkc/src/comps/mcuxClRandomModes/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClRandomModes/inc/internal/: mcuxClRandomModes_Internal_SizeDefinitions.h mcuxClRandomModes_Private_CtrDrbg.h mcuxClRandomModes_Private_CtrDrbg_BlockCipher.h mcuxClRandomModes_Private_Drbg.h mcuxClRandomModes_Private_NormalMode.h mcuxClRandomModes_Private_PatchMode.h mcuxClRandomModes_Private_PrDisabled.h mcuxClRandomModes_Private_TestMode.h
  group component/els_pkc/src/comps/mcuxClRsa/src
    ../../../../../../components/els_pkc/src/comps/mcuxClRsa/src/: mcuxClRsa_ComputeD.c mcuxClRsa_ComputeD_FUP.c mcuxClRsa_GenerateProbablePrime.c mcuxClRsa_getMillerRabinTestIterations.c mcuxClRsa_KeyGeneration_Crt.c mcuxClRsa_KeyGeneration_Crt_FUP.c mcuxClRsa_KeyGeneration_Helper.c mcuxClRsa_KeyGeneration_Plain.c mcuxClRsa_Mgf1.c mcuxClRsa_MillerRabinTest.c mcuxClRsa_MillerRabinTest_FUP.c mcuxClRsa_ModInv.c mcuxClRsa_Pkcs1v15Encode_sign.c mcuxClRsa_Pkcs1v15Verify.c mcuxClRsa_PrivateCrt.c mcuxClRsa_PrivateCrt_FUP.c mcuxClRsa_PrivatePlain.c mcuxClRsa_PssEncode.c mcuxClRsa_PssVerify.c mcuxClRsa_Public.c mcuxClRsa_PublicExp.c mcuxClRsa_RemoveBlinding.c mcuxClRsa_RemoveBlinding_FUP.c mcuxClRsa_Sign.c mcuxClRsa_Sign_NoEMSA.c mcuxClRsa_TestPQDistance.c mcuxClRsa_TestPQDistance_FUP.c mcuxClRsa_TestPrimeCandidate.c mcuxClRsa_TestPrimeCandidate_FUP.c mcuxClRsa_Verify.c mcuxClRsa_VerifyE.c mcuxClRsa_Verify_NoEMSA.c
  group component/els_pkc/src/comps/mcuxClRsa/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClRsa/inc/: mcuxClRsa.h mcuxClRsa_ComputeD_FUP.h mcuxClRsa_Constants.h mcuxClRsa_Functions.h mcuxClRsa_KeyGeneration_Crt_FUP.h mcuxClRsa_MillerRabinTest_FUP.h mcuxClRsa_PrivateCrt_FUP.h mcuxClRsa_RemoveBlinding_FUP.h mcuxClRsa_TestPQDistance_FUP.h mcuxClRsa_TestPrimeCandidate_FUP.h mcuxClRsa_Types.h
  group component/els_pkc/src/comps/mcuxClRsa/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClRsa/inc/internal/: mcuxClRsa_ComputeD_FUP.h mcuxClRsa_Internal_Functions.h mcuxClRsa_Internal_Macros.h mcuxClRsa_Internal_MemoryConsumption.h mcuxClRsa_Internal_PkcDefs.h mcuxClRsa_Internal_PkcTypes.h mcuxClRsa_Internal_Types.h mcuxClRsa_KeyGeneration_Crt_FUP.h mcuxClRsa_MillerRabinTest_FUP.h mcuxClRsa_PrivateCrt_FUP.h mcuxClRsa_RemoveBlinding_FUP.h mcuxClRsa_TestPQDistance_FUP.h mcuxClRsa_TestPrimeCandidate_FUP.h
  group component/els_pkc/src/comps/mcuxClSession/src
    ../../../../../../components/els_pkc/src/comps/mcuxClSession/src/: mcuxClSession.c
  group component/els_pkc/src/comps/mcuxClSession/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClSession/inc/: mcuxClSession.h mcuxClSession_Functions.h mcuxClSession_Types.h
  group component/els_pkc/src/comps/mcuxClSession/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClSession/inc/internal/: mcuxClSession_Internal.h mcuxClSession_Internal_EntryExit.h mcuxClSession_Internal_EntryExit_RegularReturn.h mcuxClSession_Internal_Functions.h
  group component/els_pkc/src/comps/mcuxClTrng/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClTrng/inc/internal/: mcuxClTrng_Internal.h mcuxClTrng_Internal_Constants.h mcuxClTrng_Internal_Functions.h mcuxClTrng_Internal_SA_TRNG.h mcuxClTrng_Internal_Types.h mcuxClTrng_SfrAccess.h mcuxClTrng_SfrAccess.h mcuxClTrng_Internal_SA_TRNG.h
  group component/els_pkc/src/comps/mcuxClTrng/src
    ../../../../../../components/els_pkc/src/comps/mcuxClTrng/src/: mcuxClTrng_SA_TRNG.c
  group component/els_pkc/src/comps/mcuxCsslCPreProcessor/inc
    ../../../../../../components/els_pkc/src/comps/mcuxCsslCPreProcessor/inc/: mcuxCsslAnalysis.h mcuxCsslCPreProcessor.h
  group component/els_pkc/src/comps/mcuxCsslDataIntegrity/inc
    ../../../../../../components/els_pkc/src/comps/mcuxCsslDataIntegrity/inc/: mcuxCsslDataIntegrity.h mcuxCsslDataIntegrity_Cfg.h mcuxCsslDataIntegrity_Impl.h mcuxCsslDataIntegrity_None.h
  group component/els_pkc/src/comps/mcuxCsslFlowProtection/inc
    ../../../../../../components/els_pkc/src/comps/mcuxCsslFlowProtection/inc/: mcuxCsslFlowProtection.h mcuxCsslFlowProtection_Cfg.h mcuxCsslFlowProtection_FunctionIdentifiers.h mcuxCsslFlowProtection_Impl.h mcuxCsslFlowProtection_SecureCounter_Common.h mcuxCsslFlowProtection_SecureCounter_Local.h
  group component/els_pkc/src/comps/mcuxCsslParamIntegrity/src
    ../../../../../../components/els_pkc/src/comps/mcuxCsslParamIntegrity/src/: mcuxCsslParamIntegrity32.c
  group component/els_pkc/src/comps/mcuxCsslParamIntegrity/inc
    ../../../../../../components/els_pkc/src/comps/mcuxCsslParamIntegrity/inc/: mcuxCsslParamIntegrity.h
  group component/els_pkc/src/comps/mcuxCsslSecureCounter/inc
    ../../../../../../components/els_pkc/src/comps/mcuxCsslSecureCounter/inc/: mcuxCsslSecureCounter.h mcuxCsslSecureCounter_Cfg.h mcuxCsslSecureCounter_Impl.h mcuxCsslSecureCounter_None.h mcuxCsslSecureCounter_SW_Local.h
  group component/els_pkc/src/inc
    ../../../../../../components/els_pkc/src/inc/: mcuxCl_clns.h
  group component/els_pkc/src/compiler
    ../../../../../../components/els_pkc/src/compiler/: mcuxClToolchain.h
  group component/els_pkc/src/platforms/rw61x
    ../../../../../../components/els_pkc/src/platforms/rw61x/: platform_specific_headers.h mcuxClConfig.h mcux_els.c mcux_els.h mcux_pkc.c mcux_pkc.h
  group component/els_pkc/src/platforms/rw61x/inc
    ../../../../../../components/els_pkc/src/platforms/rw61x/inc/: ip_css_constants.h ip_css_design_configuration.h ip_platform.h
  group component/els_pkc/includes
    ../../../../../../components/els_pkc/includes/: mcuxClEls_GlitchDetector.h
  group component/els_pkc/includes/platform/rw61x
    ../../../../../../components/els_pkc/includes/platform/rw61x/: mcuxClAeadModes_MemoryConsumption.h mcuxClCipherModes_MemoryConsumption.h mcuxClEcc_MemoryConsumption.h mcuxClHashModes_MemoryConsumption.h mcuxClHash_MemoryConsumption.h mcuxClHmac_MemoryConsumption.h mcuxClKey_MemoryConsumption.h mcuxClMacModes_MemoryConsumption.h mcuxClRandomModes_MemoryConsumption.h mcuxClRsa_MemoryConsumption.h mcuxClSession_MemoryConsumption.h
  group component/psa_crypto_driver/osal
    ../../../../../../components/psa_crypto_driver/osal/: osal_mutex.h threading_alt.h
  group component/psa_crypto_driver/osal/baremetal
    ../../../../../../components/psa_crypto_driver/osal/baremetal/: osal_mutex.c osal_mutex_platform.h threading_alt.c threading_alt_platform.h
  group component/psa_crypto_driver/els_pkc
    ../../../../../../components/psa_crypto_driver/els_pkc/: els_pkc_driver.h
  group component/psa_crypto_driver/els_pkc/oracle/platforms/rw61x
    ../../../../../../components/psa_crypto_driver/els_pkc/oracle/platforms/rw61x/: mcuxClPsaDriver_Oracle_KeyRecipes.h
  group component/psa_crypto_driver/els_pkc/oracle/inc
    ../../../../../../components/psa_crypto_driver/els_pkc/oracle/inc/: mcuxClPsaDriver_Oracle_Interface_builtin_key_ids.h mcuxClPsaDriver_Oracle_Interface_key_locations.h mcuxClPsaDriver_Oracle_ElsUtils.h mcuxClPsaDriver_Oracle_Macros.h mcuxClPsaDriver_Oracle_Utils.h
  group component/psa_crypto_driver/els_pkc/oracle/src
    ../../../../../../components/psa_crypto_driver/els_pkc/oracle/src/: mcuxClPsaDriver_Oracle.c mcuxClPsaDriver_Oracle_ElsUtils.c mcuxClPsaDriver_Oracle_Utils.c
  group component/psa_crypto_driver/els_pkc/include/common
    ../../../../../../components/psa_crypto_driver/els_pkc/include/common/: mcux_psa_els_pkc_common_init.h mcux_psa_els_pkc_entropy.h
  group component/psa_crypto_driver/els_pkc/include/transparent
    ../../../../../../components/psa_crypto_driver/els_pkc/include/transparent/: mcux_psa_els_pkc_aead.h mcux_psa_els_pkc_asymmetric_signature.h mcux_psa_els_pkc_cipher.h mcux_psa_els_pkc_hash.h mcux_psa_els_pkc_init.h mcux_psa_els_pkc_key_generation.h mcux_psa_els_pkc_mac.h
  group component/psa_crypto_driver/els_pkc/include/opaque
    ../../../../../../components/psa_crypto_driver/els_pkc/include/opaque/: mcux_psa_els_pkc_opaque_aead.h mcux_psa_els_pkc_opaque_asymmetric_signature.h mcux_psa_els_pkc_opaque_cipher.h mcux_psa_els_pkc_opaque_init.h mcux_psa_els_pkc_opaque_key_generation.h mcux_psa_els_pkc_opaque_mac.h
  group component/psa_crypto_driver/els_pkc/src/common
    ../../../../../../components/psa_crypto_driver/els_pkc/src/common/: mcux_psa_els_pkc_common_init.c mcux_psa_els_pkc_entropy.c
  group component/psa_crypto_driver/els_pkc/src/transparent
    ../../../../../../components/psa_crypto_driver/els_pkc/src/transparent/: mcux_psa_els_pkc_aead.c mcux_psa_els_pkc_asymmetric_signature.c mcux_psa_els_pkc_cipher.c mcux_psa_els_pkc_hash.c mcux_psa_els_pkc_init.c mcux_psa_els_pkc_key_generation.c mcux_psa_els_pkc_mac.c
  group component/psa_crypto_driver/els_pkc/src/opaque
    ../../../../../../components/psa_crypto_driver/els_pkc/src/opaque/: mcux_psa_els_pkc_opaque_aead.c mcux_psa_els_pkc_opaque_asymmetric_signature.c mcux_psa_els_pkc_opaque_cipher.c mcux_psa_els_pkc_opaque_init.c mcux_psa_els_pkc_opaque_key_generation.c mcux_psa_els_pkc_opaque_mac.c
  group component/conn_fwloader
    ../../../../../../components/conn_fwloader/: fsl_loader.c fsl_loader_utils.c nboot_hal.c life_cycle.c readme.txt
  group component/conn_fwloader/include
    ../../../../../../components/conn_fwloader/include/: api_tree_root.h fsl_loader.h fsl_loader_utils.h fusemap.h life_cycle.h nboot_rom_api_table.h
  group component/conn_fwloader/fw_bin/rw61x
    ../../../../../../components/conn_fwloader/fw_bin/rw61x/: rw61x_sb_wifi_a2.bin rw61x_sb_ble_a2.bin rw61x_sb_ble_15d4_combo_a2.bin rw61x_sb_wifi_a2_compressed.bin rw61x_sb_ble_a2_compressed.bin rw61x_sb_ble_15d4_combo_a2_compressed.bin rw61x_cpu1.c rw61x_cpu2.c
  group component/conn_fwloader/fw_bin/script
    ../../../../../../components/conn_fwloader/fw_bin/script/: wlan_gen_fw_incs.py
  group component/conn_fwloader/fw_bin/inc/rw61x
    ../../../../../../components/conn_fwloader/fw_bin/inc/rw61x/: rw61x_sb_ble_15d4_combo_a2.bin.inc rw61x_sb_ble_15d4_combo_a2_compressed.bin.inc rw61x_sb_ble_a2.bin.inc rw61x_sb_ble_a2_compressed.bin.inc rw61x_sb_wifi_a2.bin.inc rw61x_sb_wifi_a2_compressed.bin.inc
  group component/conn_fwloader/fw_bin/inc/iw610x
    ../../../../../../components/conn_fwloader/fw_bin/inc/iw610x/: sd_iw610.bin.se.inc sd_iw610_compressed.bin.se.inc sduart_iw610.bin.se.inc sduart_iw610_compressed.bin.se.inc sduartspi_iw610.bin.se.inc sduartspi_iw610_compressed.bin.se.inc uart_iw610_bt.bin.se.inc uart_iw610_bt_compressed.bin.se.inc uartspi_iw610.bin.se.inc uartspi_iw610_compressed.bin.se.inc
  group component/conn_fwloader/fw_bin/inc/8987
    ../../../../../../components/conn_fwloader/fw_bin/inc/8987/: sd8987_wlan.bin.inc sduart8987_wlan_bt.bin.inc uart8987_bt.bin.inc
  group component/conn_fwloader/fw_bin/inc/IW416
    ../../../../../../components/conn_fwloader/fw_bin/inc/IW416/: sdIW416_wlan.bin.inc sduartIW416_wlan_bt.bin.inc uartIW416_bt.bin.inc
  group component/conn_fwloader/fw_bin/inc/nw61x
    ../../../../../../components/conn_fwloader/fw_bin/inc/nw61x/: sd_nw61x.bin.se.inc sduart_nw61x.bin.se.inc sduart_nw61x_zb_dual_pan.bin.se.inc uart_nw61x.bin.se.inc uart_nw61x_zb_dual_pan.bin.se.inc
  group component/conn_fwloader/fw_bin/iw610x
    ../../../../../../components/conn_fwloader/fw_bin/iw610x/: sduart_iw610_se.h sd_iw610_se.h uart_iw610_se.h iw610_cpu12_se.c iw610_cpu2_se.c iw610_cpu1_se.c
  group component/conn_fwloader/fw_bin/8987
    ../../../../../../components/conn_fwloader/fw_bin/8987/: sduart8987_wlan_bt.h sd8987_wlan.h uart8987_bt.h 8987_cpu12.c 8987_cpu1.c 8987_cpu2.c
  group component/conn_fwloader/fw_bin/IW416
    ../../../../../../components/conn_fwloader/fw_bin/IW416/: sduartIW416_wlan_bt.h sdIW416_wlan.h uartIW416_bt.h IW416_cpu12.c IW416_cpu1.c IW416_cpu2.c
  group component/conn_fwloader/fw_bin/nw61x
    ../../../../../../components/conn_fwloader/fw_bin/nw61x/: sduart_nw61x_se.h sd_nw61x_se.h uart_nw61x_se.h sduart_nw61x_zb_dual_pan_se.h uart_nw61x_zb_dual_pan_se.h nw61x_cpu12_se.c nw61x_cpu1_se.c nw61x_cpu2_se.c
  group flash/mflash
    ../../../../../../components/flash/mflash/: mflash_common.h mflash_file.c mflash_file.h
  group flash/mflash/frdmrw612
    ../../../../../../components/flash/mflash/frdmrw612/: mflash_drv.c mflash_drv.h
  group mbedtls3x/include/mbedtls
    ../../../../../../middleware/mbedtls3x/include/mbedtls/: aes.h aria.h asn1.h asn1write.h base64.h bignum.h block_cipher.h build_info.h camellia.h ccm.h chacha20.h chachapoly.h check_config.h cipher.h cmac.h compat-2.x.h config_adjust_legacy_crypto.h config_adjust_legacy_from_psa.h config_adjust_psa_from_legacy.h config_adjust_psa_superset_legacy.h config_adjust_ssl.h config_adjust_x509.h config_psa.h constant_time.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h entropy.h error.h gcm.h hkdf.h hmac_drbg.h lms.h mbedtls_config.h md.h md5.h memory_buffer_alloc.h nist_kw.h oid.h pem.h pk.h pkcs5.h pkcs12.h platform.h platform_time.h platform_util.h poly1305.h private_access.h psa_util.h ripemd160.h rsa.h sha1.h sha3.h sha256.h sha512.h threading.h timing.h version.h
  group mbedtls3x/include/psa
    ../../../../../../middleware/mbedtls3x/include/psa/: build_info.h crypto.h crypto_adjust_auto_enabled.h crypto_adjust_config_dependencies.h crypto_adjust_config_key_pair_types.h crypto_adjust_config_synonyms.h crypto_builtin_composites.h crypto_builtin_key_derivation.h crypto_builtin_primitives.h crypto_compat.h crypto_config.h crypto_driver_common.h crypto_driver_contexts_composites.h crypto_driver_contexts_key_derivation.h crypto_driver_contexts_primitives.h crypto_extra.h crypto_legacy.h crypto_platform.h crypto_se_driver.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h crypto_config.h
  group mbedtls3x/library
    ../../../../../../middleware/mbedtls3x/library/: aes.c aesni.c aesni.h alignment.h aesce.c aesce.h aria.c asn1parse.c asn1write.c base64.c base64_internal.h bignum.c bignum_core.h bignum_core.c bignum_core_invasive.h bignum_internal.h bignum_mod.c bignum_mod.h bignum_mod_raw.c bignum_mod_raw.h bignum_mod_raw_invasive.h block_cipher.c block_cipher_internal.h bn_mul.h camellia.c ccm.c chacha20.c chachapoly.c check_crypto_config.h cipher.c cipher_invasive.h cipher_wrap.c cipher_wrap.h cmac.c common.h constant_time.c constant_time_impl.h constant_time_internal.h ctr_drbg.c ctr.h des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c ecp_curves_new.c ecp_internal_alt.h ecp_invasive.h entropy.c entropy_poll.c entropy_poll.h error.c gcm.c hkdf.c hmac_drbg.c lmots.c lmots.h lms.c md.c md_psa.h md_wrap.h md5.c memory_buffer_alloc.c nist_kw.c oid.c padlock.c padlock.h pem.c pk.c pk_ecc.c pk_internal.h pk_wrap.c pk_wrap.h pkcs5.c pkcs12.c pkparse.c pkwrite.c pkwrite.h platform.c platform_util.c poly1305.c psa_crypto_aead.h psa_crypto_cipher.h psa_crypto_core.h psa_crypto_core_common.h psa_crypto_driver_wrappers_no_static.h psa_crypto_driver_wrappers.h psa_crypto_ecp.h psa_crypto_ffdh.h psa_crypto_hash.h psa_crypto_invasive.h psa_crypto_its.h psa_crypto_mac.h psa_crypto_pake.h psa_crypto_random.h psa_crypto_random_impl.h psa_crypto_rsa.h psa_crypto_se.h psa_crypto_slot_management.h psa_crypto_storage.h psa_util_internal.h psa_util.c ripemd160.c rsa.c rsa_alt_helpers.c rsa_alt_helpers.h rsa_internal.h sha1.c sha3.c sha256.c sha512.c threading.c threading_internal.h timing.c version.c version_features.c psa_crypto.c psa_crypto_aead.c psa_crypto_cipher.c psa_crypto_client.c psa_crypto_driver_wrappers_no_static.c psa_crypto_ecp.c psa_crypto_ffdh.c psa_crypto_hash.c psa_crypto_mac.c psa_crypto_pake.c psa_crypto_random.c psa_crypto_rsa.c psa_crypto_se.c psa_crypto_slot_management.c psa_crypto_storage.c
  group mbedtls3x/port
    ../../../../../../middleware/mbedtls3x/port/: mcux_mbedtls_accelerator_config.h mcux_psa_defines.h
  group tf-m/platform/ext/target/nxp/common
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/: target_cfg_common.h crypto_accelerator_config.h mbedtls_accelerator_config.h libc_dummy.c crypto_hw.c mpc_ppc_faults.c mmio_defs.h tfm_hal_isolation.c tfm_hal_platform.c plat_test.c
  group tf-m/platform/ext/target/nxp/common/services/src
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/services/src/: tfm_platform_system.c
  group tf-m/platform/ext/target/nxp/common/Device/Config
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/Device/Config/: device_cfg.h device_cfg.h
  group tf-m/platform/ext/target/nxp/common/Device/Include
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/Device/Include/: cmsis.h device_definition.h platform_description.h platform_irq.h platform_regs.h cmsis.h device_definition.h platform_description.h platform_irq.h platform_regs.h
  group tf-m/platform/ext/target/nxp/common/CMSIS_Driver
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/CMSIS_Driver/: Driver_USART.c Driver_Flash_iap_rw61x.c Driver_Flash_iap_rw61x_iped.c Driver_USART.c
  group tf-m/platform/ext/target/nxp/frdmrw612
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/frdmrw612/: platform_psa_hw_accel.h config_tfm_target.h target_cfg.h tfm_peripherals_def.h target_cfg.c
  group tf-m/platform/ext/target/nxp/frdmrw612/Device/Include
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/frdmrw612/Device/Include/: platform_base_address.h
  group tf-m/platform/ext/target/nxp/frdmrw612/Device/Source
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/frdmrw612/Device/Source/: startup_frdmrw612.c
  group tf-m/platform/ext/target/nxp/frdmrw612/partition
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/frdmrw612/partition/: region_defs.h flash_layout.h
  group tf-m/platform/ext/target/nxp/rw61x
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/rw61x/: crypto_keys.c nv_counters.c platform_sp.c load_info_tfm_internal_trusted_storage.c
  group tf-m/platform/ext/target/nxp/rw61x/platform/include
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/rw61x/platform/include/: platform_nv_counters_ids.h platform_nv_counters_ids.h
  group tf-m/platform/ext/target/nxp/rw61x/partitions/loader_service
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/rw61x/partitions/loader_service/: tfm_lds_pid.h tfm_lds_sid.h tfm_lds_config.h tfm_lds_func_ids.h tfm_lds_req_mngr.h tfm_lds_req_mngr.c
  group tf-m/platform/ext/target/nxp/rw61x/partitions/loader_service/interface/include
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/rw61x/partitions/loader_service/interface/include/: tfm_lds_defs.h
  group tf-m/platform/ext/target/nxp/rw61x/partitions/loader_service/interface/src
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/rw61x/partitions/loader_service/interface/src/: tfm_lds_api.c
  group tf-m/platform/ext/target/nxp/rw61x/partitions/loader_service/auto_generated
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/rw61x/partitions/loader_service/auto_generated/: intermedia_tfm_loader_service.c load_info_tfm_loader_service.c
  group tf-m/platform/ext/target/nxp/rw61x/partitions/loader_service/psa_manifest
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/rw61x/partitions/loader_service/psa_manifest/: tfm_loader_service.h
  group tf-m/platform/ext/target/arm/drivers/mpu/armv8m
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/arm/drivers/mpu/armv8m/: mpu_armv8m_drv.c mpu_armv8m_drv.h
  group tf-m/platform/ext/driver
    ../../../../../../middleware/tfm/tf-m/platform/ext/driver/: Driver_Common.h Driver_Flash.h Driver_MPC.h Driver_PPC.h Driver_USART.h
  group tf-m/platform/ext/common
    ../../../../../../middleware/tfm/tf-m/platform/ext/common/: common_target_cfg.h core_ext.h faults.c provisioning.c tfm_hal_its.c tfm_hal_nvic.c tfm_hal_ps.c tfm_hal_sp_logdev.h tfm_hal_sp_logdev_periph.c tfm_hal_spm_logdev.h tfm_hal_spm_logdev_peripheral.c tfm_hal_reset_halt.c tfm_interrupts.c tfm_s_linker_alignments.h uart_stdout.c uart_stdout.h tfm_fatal_error.c tfm_sanitize_handlers.c syscalls_stub.c tfm_hal_sp_logdev.h tfm_hal_spm_logdev.h
  group tf-m/platform/ext/common/template
    ../../../../../../middleware/tfm/tf-m/platform/ext/common/template/: attest_hal.c flash_otp_nv_counters_backend.c flash_otp_nv_counters_backend.h otp_flash.c tfm_fih_rng.c
  group tf-m/platform/ext/accelerator/interface
    ../../../../../../middleware/tfm/tf-m/platform/ext/accelerator/interface/: crypto_hw.h
  group tf-m/platform/include
    ../../../../../../middleware/tfm/tf-m/platform/include/: tfm_hal_device_header.h region.h cmsis_override.h
  group tf-m/lib/fih/inc
    ../../../../../../middleware/tfm/tf-m/lib/fih/inc/: fih.h tfm_fih_rng.h fih.h
  group tf-m/lib/fih/src
    ../../../../../../middleware/tfm/tf-m/lib/fih/src/: fih.c
  group tf-m/lib/ext/mbedcrypto/mbedcrypto_config
    ../../../../../../middleware/tfm/tf-m/lib/ext/mbedcrypto/mbedcrypto_config/: tfm_mbedcrypto_config_profile_large.h crypto_config_profile_large.h tfm_mbedcrypto_config_extra_nv_seed.h
  group tf-m/secure_fw/spm/include
    ../../../../../../middleware/tfm/tf-m/secure_fw/spm/include/: aapcs_local.h bitops.h critical_section.h config_spm.h current.h lists.h tfm_core_trustzone.h tfm_nspm.h tfm_spm_log.h tfm_version.h utilities.h tfm_arch.h tfm_arch_v8m.h config_spm.h
  group tf-m/secure_fw/spm/include/boot
    ../../../../../../middleware/tfm/tf-m/secure_fw/spm/include/boot/: tfm_boot_status.h
  group tf-m/secure_fw/spm/include/interface
    ../../../../../../middleware/tfm/tf-m/secure_fw/spm/include/interface/: runtime_defs.h svc_num.h runtime_defs.h svc_num.h
  group tf-m/secure_fw/spm/include/ffm
    ../../../../../../middleware/tfm/tf-m/secure_fw/spm/include/ffm/: mailbox_agent_api.h backend.h psa_api.h backend_ipc.h
  group tf-m/secure_fw/spm/include/private
    ../../../../../../middleware/tfm/tf-m/secure_fw/spm/include/private/: assert.h
  group tf-m/secure_fw/spm/include/load
    ../../../../../../middleware/tfm/tf-m/secure_fw/spm/include/load/: asset_defs.h interrupt_defs.h partition_defs.h service_defs.h spm_load_api.h
  group tf-m/secure_fw/spm/core
    ../../../../../../middleware/tfm/tf-m/secure_fw/spm/core/: psa_api.c psa_call_api.c psa_connection_api.c psa_irq_api.c psa_mmiovec_api.c psa_read_write_skip_api.c psa_version_api.c interrupt.c interrupt.h spm_connection_pool.c spm_log.c stack_watermark.c stack_watermark.h tfm_boot_data.c tfm_boot_data.h tfm_multi_core.h utilities.c internal_status_code.h main.c memory_symbols.h tfm_pools.h tfm_rpc.h tfm_svcalls.h rom_loader.c spm_ipc.c spm.h tfm_svcalls.c tfm_pools.c spm.h backend_ipc.c psa_interface_thread_fn_call.c psa_interface_svc.c thread.c thread.h
  group tf-m/secure_fw/spm/core/arch
    ../../../../../../middleware/tfm/tf-m/secure_fw/spm/core/arch/: tfm_arch.c tfm_arch_v8m_main.c
  group tf-m/secure_fw/spm/ns_client_ext
    ../../../../../../middleware/tfm/tf-m/secure_fw/spm/ns_client_ext/: tfm_ns_ctx.h tfm_spm_ns_ctx.c
  group tf-m/secure_fw/include
    ../../../../../../middleware/tfm/tf-m/secure_fw/include/: array.h async.h build_config_check.h compiler_ext_defs.h config_tfm.h security_defs.h config_tfm.h
  group tf-m/secure_fw/partitions/lib/runtime
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/lib/runtime/: service_api.c sprt_partition_metadata_indicator.c sprt_partition_metadata_indicator.h tfm_sp_log_raw.c crt_strnlen.c sfn_common_thread.c psa_api_ipc.c
  group tf-m/secure_fw/partitions/lib/runtime/include
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/lib/runtime/include/: service_api.h tfm_sp_log.h tfm_strnlen.h service_api.h tfm_sp_log.h
  group tf-m/secure_fw/partitions/ns_agent_tz
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/ns_agent_tz/: load_info_ns_agent_tz.c ns_agent_tz_v80m.c psa_api_veneers_v80m.c
  group tf-m/secure_fw/partitions/idle_partition
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/idle_partition/: idle_partition.c load_info_idle_sp.c
  group tf-m/secure_fw/partitions/crypto
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/crypto/: config_engine_buf.h config_crypto_check.h crypto_aead.c crypto_alloc.c crypto_asymmetric.c crypto_check_config.h crypto_cipher.c crypto_hash.c crypto_init.c crypto_key_derivation.c crypto_key_management.c crypto_library.c crypto_library.h crypto_mac.c crypto_rng.c crypto_spe.h tfm_crypto_api.h tfm_crypto_key.h tfm_mbedcrypto_include.h
  group tf-m/secure_fw/partitions/crypto/psa_manifest
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/crypto/psa_manifest/: tfm_crypto.h tfm_crypto.h
  group tf-m/secure_fw/partitions/crypto/psa_driver_api
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/crypto/psa_driver_api/: tfm_builtin_key_loader.h tfm_builtin_key_loader.c tfm_builtin_key_loader.h
  group tf-m/secure_fw/partitions/crypto/auto_generated
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/crypto/auto_generated/: intermedia_tfm_crypto.c load_info_tfm_crypto.c
  group tf-m/secure_fw/partitions/platform
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/platform/: platform_sp.h
  group tf-m/secure_fw/partitions/platform/auto_generated
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/platform/auto_generated/: intermedia_tfm_platform.c load_info_tfm_platform.c
  group tf-m/secure_fw/partitions/platform/psa_manifest
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/platform/psa_manifest/: tfm_platform.h
  group tf-m/secure_fw/partitions/initial_attestation/auto_generated
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/initial_attestation/auto_generated/: load_info_tfm_initial_attestation.c
  group tf-m/secure_fw/partitions/initial_attestation/psa_manifest
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/initial_attestation/psa_manifest/: tfm_initial_attestation.h
  group tf-m/secure_fw/partitions/protected_storage
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/protected_storage/: ps_object_defs.h config_ps_check.h
  group tf-m/secure_fw/partitions/protected_storage/auto_generated
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/protected_storage/auto_generated/: load_info_tfm_protected_storage.c
  group tf-m/secure_fw/partitions/protected_storage/psa_manifest
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/protected_storage/psa_manifest/: tfm_protected_storage.h
  group tf-m/secure_fw/partitions/protected_storage/crypto
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/protected_storage/crypto/: ps_crypto_interface.h
  group tf-m/secure_fw/partitions/internal_trusted_storage
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/internal_trusted_storage/: its_utils.c its_utils.h tfm_internal_trusted_storage.c tfm_internal_trusted_storage.h tfm_its_req_mngr.c tfm_its_req_mngr.h
  group tf-m/secure_fw/partitions/internal_trusted_storage/auto_generated
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/internal_trusted_storage/auto_generated/: intermedia_tfm_internal_trusted_storage.c
  group tf-m/secure_fw/partitions/internal_trusted_storage/psa_manifest
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/internal_trusted_storage/psa_manifest/: tfm_internal_trusted_storage.h
  group tf-m/secure_fw/partitions/internal_trusted_storage/flash
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/internal_trusted_storage/flash/: its_flash.c its_flash.h its_flash_nand.c its_flash_nand.h its_flash_nor.c its_flash_nor.h its_flash_ram.c its_flash_ram.h
  group tf-m/secure_fw/partitions/internal_trusted_storage/flash_fs
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/internal_trusted_storage/flash_fs/: its_flash_fs.c its_flash_fs.h its_flash_fs_dblock.c its_flash_fs_dblock.h its_flash_fs_mblock.c its_flash_fs_mblock.h
  group tf-m/config
    ../../../../../../middleware/tfm/tf-m/config/: config_base.h config_base.h
  group tf-m/config/profile
    ../../../../../../middleware/tfm/tf-m/config/profile/: config_profile_large.h
  group tf-m/interface/src
    ../../../../../../middleware/tfm/tf-m/interface/src/: tfm_psa_call.c tfm_platform_api.c tfm_its_api.c
  group tf-m/interface/include
    ../../../../../../middleware/tfm/tf-m/interface/include/: tfm_its_defs.h
  group tf-m/autogenerated/secure_fw/test_services/tfm_ps_test_service/auto_generated
    ../../../../../../middleware/tfm/tf-m/autogenerated/secure_fw/test_services/tfm_ps_test_service/auto_generated/: intermedia_tfm_ps_test_service.c load_info_tfm_ps_test_service.c
  group tf-m/autogenerated/secure_fw/test_services/tfm_ps_test_service/psa_manifest
    ../../../../../../middleware/tfm/tf-m/autogenerated/secure_fw/test_services/tfm_ps_test_service/psa_manifest/: tfm_ps_test_service.h
  group tf-m/autogenerated/secure_fw/test_services/tfm_secure_client_service/auto_generated
    ../../../../../../middleware/tfm/tf-m/autogenerated/secure_fw/test_services/tfm_secure_client_service/auto_generated/: intermedia_tfm_secure_client_service.c load_info_tfm_secure_client_service.c
  group tf-m/autogenerated/secure_fw/test_services/tfm_secure_client_service/psa_manifest
    ../../../../../../middleware/tfm/tf-m/autogenerated/secure_fw/test_services/tfm_secure_client_service/psa_manifest/: tfm_secure_client_service.h
  group tf-m/autogenerated/secure_fw/test_services/tfm_secure_client_2/auto_generated
    ../../../../../../middleware/tfm/tf-m/autogenerated/secure_fw/test_services/tfm_secure_client_2/auto_generated/: intermedia_tfm_secure_client_2.c load_info_tfm_secure_client_2.c
  group tf-m/autogenerated/secure_fw/test_services/tfm_secure_client_2/psa_manifest
    ../../../../../../middleware/tfm/tf-m/autogenerated/secure_fw/test_services/tfm_secure_client_2/psa_manifest/: tfm_secure_client_2.h
  group tf-m/autogenerated/secure_fw/test_services/tfm_ipc_service/auto_generated
    ../../../../../../middleware/tfm/tf-m/autogenerated/secure_fw/test_services/tfm_ipc_service/auto_generated/: intermedia_tfm_ipc_service_test.c load_info_tfm_ipc_service_test.c
  group tf-m/autogenerated/secure_fw/test_services/tfm_ipc_service/psa_manifest
    ../../../../../../middleware/tfm/tf-m/autogenerated/secure_fw/test_services/tfm_ipc_service/psa_manifest/: tfm_ipc_service_test.h
  group tf-m/autogenerated/secure_fw/test_services/tfm_ipc_client/auto_generated
    ../../../../../../middleware/tfm/tf-m/autogenerated/secure_fw/test_services/tfm_ipc_client/auto_generated/: intermedia_tfm_ipc_client_test.c load_info_tfm_ipc_client_test.c
  group tf-m/autogenerated/secure_fw/test_services/tfm_ipc_client/psa_manifest
    ../../../../../../middleware/tfm/tf-m/autogenerated/secure_fw/test_services/tfm_ipc_client/psa_manifest/: tfm_ipc_client_test.h
  group tf-m/autogenerated/secure_fw/test_services/tfm_slih_test_service/auto_generated
    ../../../../../../middleware/tfm/tf-m/autogenerated/secure_fw/test_services/tfm_slih_test_service/auto_generated/: intermedia_tfm_slih_test_service.c load_info_tfm_slih_test_service.c
  group tf-m/autogenerated/secure_fw/test_services/tfm_slih_test_service/psa_manifest
    ../../../../../../middleware/tfm/tf-m/autogenerated/secure_fw/test_services/tfm_slih_test_service/psa_manifest/: tfm_slih_test_service.h
  group tfm/tf-m/platform/include
    ../../../../../../middleware/tfm/tf-m/platform/include/: boot_hal.h cmsis_override.h exception_info.h fatal_error.h mbedtls_entropy_nv_seed_config.h region.h tfm_attest_hal.h tfm_hal_defs.h tfm_hal_device_header.h tfm_hal_interrupt.h tfm_hal_isolation.h tfm_hal_its.h tfm_hal_its_encryption.h tfm_hal_mailbox.h tfm_hal_multi_core.h tfm_hal_platform.h tfm_hal_ps.h tfm_plat_boot_seed.h tfm_plat_config.h tfm_plat_crypto_keys.h tfm_plat_crypto_nv_seed.h tfm_plat_defs.h tfm_plat_device_id.h tfm_plat_ns.h tfm_plat_nv_counters.h tfm_plat_otp.h tfm_plat_provisioning.h tfm_plat_rotpk.h tfm_plat_test.h tfm_platform_system.h
  group tfm/tf-m/interface/include
    ../../../../../../middleware/tfm/tf-m/interface/include/: config_impl.h tfm_attest_defs.h tfm_attest_iat_defs.h tfm_crypto_defs.h tfm_fwu_defs.h tfm_its_defs.h tfm_ns_client_ext.h tfm_ns_interface.h tfm_platform_api.h tfm_ps_defs.h tfm_psa_call_pack.h tfm_veneers.h
  group tfm/tf-m/interface/include/psa_manifest
    ../../../../../../middleware/tfm/tf-m/interface/include/psa_manifest/: sid.h pid.h
  group tfm/tf-m/interface/include/psa
    ../../../../../../middleware/tfm/tf-m/interface/include/psa/: build_info.h client.h crypto.h crypto_adjust_auto_enabled.h crypto_adjust_config_dependencies.h crypto_adjust_config_key_pair_types.h crypto_adjust_config_synonyms.h crypto_builtin_composites.h crypto_builtin_key_derivation.h crypto_builtin_primitives.h crypto_compat.h crypto_driver_common.h crypto_driver_contexts_composites.h crypto_driver_contexts_key_derivation.h crypto_driver_contexts_primitives.h crypto_extra.h crypto_legacy.h crypto_platform.h crypto_se_driver.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h error.h framework_feature.h initial_attestation.h internal_trusted_storage.h lifecycle.h protected_storage.h service.h storage_common.h update.h
  group tfm/tf-m/interface/include/mbedtls
    ../../../../../../middleware/tfm/tf-m/interface/include/mbedtls/: aes.h aria.h asn1.h asn1write.h base64.h bignum.h block_cipher.h build_info.h camellia.h ccm.h chacha20.h chachapoly.h check_config.h cipher.h cmac.h compat-2.x.h config_adjust_legacy_crypto.h config_adjust_legacy_from_psa.h config_adjust_psa_from_legacy.h config_adjust_psa_superset_legacy.h config_adjust_ssl.h config_adjust_x509.h config_psa.h constant_time.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h entropy.h error.h gcm.h hkdf.h hmac_drbg.h lms.h md.h md5.h memory_buffer_alloc.h net_sockets.h nist_kw.h oid.h pem.h pk.h pkcs12.h pkcs5.h pkcs7.h platform.h platform_time.h platform_util.h poly1305.h private_access.h psa_util.h ripemd160.h rsa.h sha1.h sha256.h sha3.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h
  group tfm/tf-m/interface/include/crypto_keys
    ../../../../../../middleware/tfm/tf-m/interface/include/crypto_keys/: tfm_builtin_key_ids.h
  group tf-m-tests/tests_reg/test/secure_fw/suites/ps/secure
    ../../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/suites/ps/secure/: s_test_helpers.h ps_tests.h
  group tf-m-tests/tests_reg/test/secure_fw/suites/platform
    ../../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/suites/platform/: platform_tests_common.c platform_tests_common.h
  group tf-m-tests/tests_reg/test/secure_fw/suites/platform/secure
    ../../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/suites/platform/secure/: platform_s_tests.h platform_s_tests.h platform_s_interface_testsuite.c
  group tf-m-tests/tests_reg/test/secure_fw/suites/attestation/secure
    ../../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/suites/attestation/secure/: attest_s_tests.h
  group tf-m-tests/tests_reg/test/secure_fw/suites/crypto/secure
    ../../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/suites/crypto/secure/: crypto_s_tests.h
  group tf-m-tests/tests_reg/test/secure_fw/suites/its/secure
    ../../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/suites/its/secure/: its_s_tests.h
  group tf-m-tests/tests_reg/test/secure_fw/suites/spm/common
    ../../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/suites/spm/common/: spm_test_defs.h spm_test_defs.h
  group tf-m-tests/tests_reg/test/secure_fw/suites/spm/common/suites
    ../../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/suites/spm/common/suites/: client_api_tests.c client_api_tests.h
  group tf-m-tests/tests_reg/test/secure_fw/suites/spm/common/service
    ../../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/suites/spm/common/service/: client_api_test_defs.h client_api_test_service.c client_api_test_service.h
  group tf-m-tests/tests_reg/test/secure_fw/suites/spm/ipc/secure
    ../../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/suites/spm/ipc/secure/: ipc_s_tests.h ipc_s_interface_testsuite.c
  group tf-m-tests/tests_reg/test/secure_fw/suites/spm/ipc/service/tfm_ipc_service
    ../../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/suites/spm/ipc/service/tfm_ipc_service/: tfm_ipc_service_test.c
  group tf-m-tests/tests_reg/test/secure_fw/suites/spm/ipc/service/tfm_ipc_client
    ../../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/suites/spm/ipc/service/tfm_ipc_client/: tfm_ipc_client_test.c
  group tf-m-tests/tests_reg/test/secure_fw/suites/spm/irq/service/tfm_slih_test_service
    ../../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/suites/spm/irq/service/tfm_slih_test_service/: tfm_slih_test_service.c
  group tf-m-tests/tests_reg/test/secure_fw/common_test_services/tfm_secure_client_service
    ../../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/common_test_services/tfm_secure_client_service/: tfm_secure_client_service.c tfm_secure_client_service.h
  group tf-m-tests/tests_reg/test/secure_fw/common_test_services/tfm_secure_client_2
    ../../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_fw/common_test_services/tfm_secure_client_2/: tfm_secure_client_2_api.h
  group tf-m-tests/tests_reg/test/secure_regression
    ../../../../../../middleware/tfm/tf-m-tests/tests_reg/test/secure_regression/: secure_suites.c secure_suites.h
  group tf-m-tests/tests_reg/test/framework
    ../../../../../../middleware/tfm/tf-m-tests/tests_reg/test/framework/: test_framework.c test_framework.h test_framework_error_codes.h test_framework_helpers.c test_framework_helpers.h test_log.h
  group source
    ../: fsl_os_abstraction_config.h mcux_config.h mcux_config.h mcux_config.h mcuxsdk_version.h
  group doc
    ../: readme.md example_board_readme.md
