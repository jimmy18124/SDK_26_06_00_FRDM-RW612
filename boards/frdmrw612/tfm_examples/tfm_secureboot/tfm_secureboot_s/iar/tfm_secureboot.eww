<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>tfm_secureboot_s</project>
        <configuration>debug</configuration>
      </member>
      <member>
        <project>tfm_secureboot_s</project>
        <configuration>release</configuration>
      </member>
      <member>
        <project>tfm_secureboot_ns</project>
        <configuration>debug</configuration>
      </member>
      <member>
        <project>tfm_s_crypto_clients</project>
        <configuration>debug</configuration>
      </member>
      <member>
        <project>tfm_secureboot_ns</project>
        <configuration>release</configuration>
      </member>
      <member>
        <project>tfm_s_crypto_clients</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>tfm_secureboot_s</project>
        <configuration>debug</configuration>
      </member>
      <member>
        <project>tfm_secureboot_ns</project>
        <configuration>debug</configuration>
      </member>
      <member>
        <project>tfm_s_crypto_clients</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>tfm_secureboot_s</project>
        <configuration>release</configuration>
      </member>
      <member>
        <project>tfm_secureboot_ns</project>
        <configuration>release</configuration>
      </member>
      <member>
        <project>tfm_s_crypto_clients</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/tfm_secureboot_s.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/../../tfm_secureboot_ns/iar/tfm_secureboot_ns.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/../../../../lib_projects/tfm_s_crypto_clients/iar/tfm_s_crypto_clients.ewp</path>
  </project>
</workspace>
