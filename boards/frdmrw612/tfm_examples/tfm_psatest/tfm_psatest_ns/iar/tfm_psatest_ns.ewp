# IAR project tfm_psatest_ns.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: RW612 NXP RW612
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; PLATFORM_HAS_ATTEST_PK; OS_DYNAMIC_MEM_SIZE=7168; PSA_API_TEST_NS=1; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_RW612ETA2I; RW612_SERIES; BOOT_HEADER_ENABLE=1; CMSIS_device_header="fsl_device_registers.h"; RTE_COMPONENTS_H; TARGET_CONFIG_HEADER_FILE="config_tfm_target.h"; QCBOR_DISABLE_FLOAT_HW_USE; USEFULBUF_DISABLE_ALL_FLOAT; QCBOR_DISABLE_PREFERRED_FLOAT; TFM_ISOLATION_LEVEL=2; CONFIG_TFM_PARTITION_META; CONFIG_TFM_SPM_BACKEND_IPC=1; PROJECT_CONFIG_HEADER_FILE="config_profile_large.h"; MBEDTLS_CONFIG_FILE="tfm_mbedcrypto_config_profile_large_client.h"; TF_M_PROFILE_LARGE; CONFIG_TFM_FLOAT_ABI=2; CONFIG_TFM_ENABLE_CP10CP11; CONFIG_TFM_LAZY_STACKING; __DOMAIN_NS=1; DOMAIN_NS=1; CONFIG_TFM_USE_TRUSTZONE; ATTEST_TOKEN_PROFILE_PSA_IOT_1; PLATFORM_DEFAULT_CRYPTO_KEYS; PS_ENCRYPTION; DISABLE_ECC_R1_CURVE_TESTS_LESS_THAN_255_BITS; CRYPTO; INITIAL_ATTESTATION; PROTECTED_STORAGE; PS_TEST; INTERNAL_TRUSTED_STORAGE; ITS_TEST
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pa084,Pa205,Pe128,Pe186,Pe546,Pe940,Pe550,Pa167,Pe177,Pe111,Pe188,Pe161,Pe223
  ICCARM.IExtraOptions: --preinclude ../mcuxsdk_version.h --diag_suppress=Pa082,Pa050
  ICCARM.PreInclude: ../mcux_config.h
  ICCARM.CCIncludePath2: ..; ../../../../flash_config; ../../../../../../devices/RW612/drivers; ../../../../../../CMSIS/RTOS2/Include; ../../../../../../CMSIS/RTOS2/RTX/Include; ../../../../../../CMSIS/RTOS2/RTX/Config; ../../../../../../CMSIS/Core/Include; ../../../../../../CMSIS/Core/Include/m-profile; ../../../../../../devices/RW612; ../../../../../../devices/RW612/periph; ../../../../../../devices/RW612/utilities/debug_console_lite; ../../../../../../devices/RW612/utilities/str; ../../../../../../components/uart; ../../../../../../components/els_pkc; ../../../../../../components/els_pkc/src/comps/mcuxClBuffer/inc; ../../../../../../components/els_pkc/src/comps/mcuxClBuffer/inc/internal; ../../../../../../components/els_pkc/src/comps/mcuxClCore/inc; ../../../../../../components/els_pkc/src/comps/mcuxClEls/inc; ../../../../../../components/els_pkc/src/comps/mcuxClEls/inc/internal; ../../../../../../components/els_pkc/src/comps/mcuxClMemory/inc; ../../../../../../components/els_pkc/src/comps/mcuxClMemory/inc/internal; ../../../../../../components/els_pkc/src/comps/mcuxCsslMemory/inc; ../../../../../../components/els_pkc/src/comps/mcuxCsslMemory/inc/internal; ../../../../../../components/els_pkc/src/comps/mcuxCsslCPreProcessor/inc; ../../../../../../components/els_pkc/src/comps/mcuxCsslDataIntegrity/inc; ../../../../../../components/els_pkc/src/comps/mcuxCsslFlowProtection/inc; ../../../../../../components/els_pkc/src/comps/mcuxCsslParamIntegrity/inc; ../../../../../../components/els_pkc/src/comps/mcuxCsslSecureCounter/inc; ../../../../../../components/els_pkc/src/compiler; ../../../../../../components/els_pkc/src/platforms/rw61x; ../../../../../../components/els_pkc/src/platforms/rw61x/inc; ../../../../../../components/els_pkc/includes/platform/rw61x; ../../../../../../components/conn_fwloader/include; ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common; ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/frdmrw612; ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/frdmrw612/partition; ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/frdmrw612/Device/Include; ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/rw61x/platform/include; ../../../../../../middleware/tfm/tf-m/platform/ext/driver; ../../../../../../middleware/mbedtls3x/include; ../../../../../../middleware/tfm/tf-m/platform/include; ../../../../../../middleware/tfm/tf-m/interface/include; ../../../../../../middleware/tfm/tf-m/interface/include/psa; ../../../../../../middleware/tfm/tf-m/interface/include/crypto_keys; ../../../../../../middleware/tfm/tf-m/interface/include/psa_manifest; ../../../../../../middleware/tfm/qcbor/src; ../../../../../../middleware/tfm/qcbor/inc; ../../../../../../middleware/tfm/qcbor/inc/qcbor; ../../../../../../middleware/tfm/tf-m/config/profile; ../../../../../../middleware/tfm/tf-m/lib/ext/mbedcrypto/mbedcrypto_config; ../../../../../../middleware/tfm/tf-m/platform/ext; ../../../../../../middleware/tfm/tf-m/platform/ext/common; ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/Device/Config; ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/Device/Include; ../../../../../../middleware/tfm/tf-m/interface/include/os_wrapper; ../../../../../../middleware/tfm/tf-m/secure_fw/spm/include; ../../../../../../middleware/tfm/tf-m/secure_fw/include; ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/crypto; ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/initial_attestation; ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/internal_trusted_storage; ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/protected_storage; ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/platform; ../../../../../../middleware/tfm/tf-m/config; ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/rw61x/partitions/loader_service; ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/rw61x/partitions/loader_service/interface/include; ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/rw61x/plat_iak_pk; ../../../../../../middleware/tfm/tf-m-tests/app_broker; ../../../../../../middleware/tfm/tf-m-tests/lib; ../../../../../../middleware/tfm/tf-m-tests/lib/os_wrapper; ../../../../../../middleware/tfm/tf-m-tests/lib/log; ../../../../../../middleware/tfm/tf-m-tests/lib/nsid_manager; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/val/nspe; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/val/common; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/platform/drivers/nvmem; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/platform/targets/common/nspe/crypto; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/platform/targets/common/nspe; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/val; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/platform/targets/tgt_dev_apis_nxp/nspe; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/common; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c001; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c002; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c003; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c004; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c005; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c006; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c007; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c008; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c009; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c010; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c011; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c012; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c013; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c014; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c015; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c016; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c017; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c018; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c019; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c020; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c021; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c022; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c023; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c024; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c025; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c026; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c027; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c028; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c029; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c030; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c031; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c032; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c033; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c034; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c035; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c036; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c037; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c038; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c039; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c040; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c041; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c042; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c043; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c044; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c045; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c046; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c047; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c048; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c049; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c050; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c051; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c052; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c053; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c054; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c055; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c056; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c057; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c058; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c059; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c060; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c061; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/platform/targets/common/nspe/initial_attestation; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/initial_attestation/test_a001; ../../../../../../middleware/tfm/tf-m/lib/ext/t_cose/inc; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/platform/targets/common/nspe/protected_storage; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s001; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s002; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s003; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s004; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s005; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s006; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s007; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s008; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s009; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s010; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s011; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s012; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s013; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s014; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s015; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s016; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s017; ../../../../../../middleware/tfm/psa-arch-tests/api-tests/platform/targets/common/nspe/internal_trusted_storage
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: MCUXPRESSO_SDK; CPU_RW612ETA2I; RW612_SERIES
  AARM.AUserIncludes: as above
  AARM.PreInclude: ../mcux_config.h
  ILINK.IlinkOutputFile: tfm_psatest_ns.out
  ILINK.IlinkIcfFile: ../../../../../../middleware/tfm/tf-m/platform/ext/common/iar/tfm_common_ns_pre.icf
  ILINK.IlinkAdditionalLibs: ../../tfm_psatest_s/iar/debug/tfm_psatest_s_import_lib.o
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; PLATFORM_HAS_ATTEST_PK; OS_DYNAMIC_MEM_SIZE=7168; PSA_API_TEST_NS=1; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_RW612ETA2I; RW612_SERIES; BOOT_HEADER_ENABLE=1; CMSIS_device_header="fsl_device_registers.h"; RTE_COMPONENTS_H; TARGET_CONFIG_HEADER_FILE="config_tfm_target.h"; QCBOR_DISABLE_FLOAT_HW_USE; USEFULBUF_DISABLE_ALL_FLOAT; QCBOR_DISABLE_PREFERRED_FLOAT; TFM_ISOLATION_LEVEL=2; CONFIG_TFM_PARTITION_META; CONFIG_TFM_SPM_BACKEND_IPC=1; PROJECT_CONFIG_HEADER_FILE="config_profile_large.h"; MBEDTLS_CONFIG_FILE="tfm_mbedcrypto_config_profile_large_client.h"; TF_M_PROFILE_LARGE; CONFIG_TFM_FLOAT_ABI=2; CONFIG_TFM_ENABLE_CP10CP11; CONFIG_TFM_LAZY_STACKING; __DOMAIN_NS=1; DOMAIN_NS=1; CONFIG_TFM_USE_TRUSTZONE; ATTEST_TOKEN_PROFILE_PSA_IOT_1; PLATFORM_DEFAULT_CRYPTO_KEYS; PS_ENCRYPTION; DISABLE_ECC_R1_CURVE_TESTS_LESS_THAN_255_BITS; CRYPTO; INITIAL_ATTESTATION; PROTECTED_STORAGE; PS_TEST; INTERNAL_TRUSTED_STORAGE; ITS_TEST
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../tfm_psatest_s/iar/release/tfm_psatest_s_import_lib.o
  group board
    ../: board.h board.c clock_config.h clock_config.c pin_mux.h pin_mux.c hardware_init.c app.h
  group flash_config
    ../../../../flash_config/: flash_config.c flash_config.h
  group drivers
    ../../../../../../devices/RW612/drivers/: fsl_clock.c fsl_clock.h fsl_i2s_bridge.c fsl_i2s_bridge.h fsl_inputmux_connections.h fsl_io_mux.h fsl_iped.c fsl_iped.h fsl_memory.h fsl_ocotp.c fsl_ocotp.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_cache.c fsl_cache.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_ctimer.h fsl_ctimer.c fsl_flexcomm.h fsl_flexcomm.c fsl_usart.h fsl_usart.c fsl_flexspi.c fsl_flexspi.h fsl_gpio.h fsl_gpio.c
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/RTOS2/Include
    ../../../../../../CMSIS/RTOS2/Include/: cmsis_os2.h os_tick.h
  group CMSIS/RTOS2/RTX/Source
    ../../../../../../CMSIS/RTOS2/RTX/Source/: rtx_core_c.h rtx_core_ca.h rtx_core_cm.h rtx_delay.c rtx_evflags.c rtx_evr.c rtx_kernel.c rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c rtx_lib.c rtx_lib.h
  group CMSIS/RTOS2/RTX/Source/IAR
    ../../../../../../CMSIS/RTOS2/RTX/Source/IAR/: irq_armv8mml.s
  group CMSIS/RTOS2/RTX/Include
    ../../../../../../CMSIS/RTOS2/RTX/Include/: rtx_evr.h rtx_os.h rtx_def.h
  group CMSIS/RTOS2/RTX/Config
    ../../../../../../CMSIS/RTOS2/RTX/Config/: RTX_Config.c RTX_Config.h
  group CMSIS/RTOS2/Source
    ../../../../../../CMSIS/RTOS2/Source/: os_systick.c
  group CMSIS/m-profile
    ../../../../../../CMSIS/Core/Include/m-profile/: cmsis_iccarm_m.h armv8m_mpu.h
  group device
    ../../../../../../devices/RW612/: fsl_device_registers.h RW612.h RW612_features.h RW612_COMMON.h system_RW612.c system_RW612.h
  group device/periph
    ../../../../../../devices/RW612/periph/: PERI_ACOMP.h PERI_ADC.h PERI_AHB_SECURE_CTRL.h PERI_AON_SOC_CIU.h PERI_APU.h PERI_BG.h PERI_BLEAPU.h PERI_BUCK11.h PERI_BUCK18.h PERI_CACHE64_CTRL.h PERI_CACHE64_POLSEL.h PERI_CAU.h PERI_CDOG.h PERI_CIU1.h PERI_CIU2.h PERI_CLKCTL0.h PERI_CLKCTL1.h PERI_CRC.h PERI_CTIMER.h PERI_DAC.h PERI_DBGMAILBOX.h PERI_DMA.h PERI_DMIC.h PERI_ELS.h PERI_ENET.h PERI_FLEXCOMM.h PERI_FLEXSPI.h PERI_FREQME.h PERI_GDMA.h PERI_GPIO.h PERI_I2C.h PERI_I2S.h PERI_INPUTMUX.h PERI_ITRC.h PERI_LCDIC.h PERI_MCI_IO_MUX.h PERI_MRT.h PERI_OCOTP.h PERI_OSTIMER.h PERI_PINT.h PERI_PKC.h PERI_PMU.h PERI_POWERQUAD.h PERI_PUF.h PERI_RF_SYSCON.h PERI_ROMCP.h PERI_RSTCTL0.h PERI_RSTCTL1.h PERI_RTC.h PERI_SCT.h PERI_SDU_FBR_CARD.h PERI_SDU_FN0_CARD.h PERI_SDU_FN_CARD.h PERI_SENSOR_CTRL.h PERI_SOCCIU.h PERI_SOC_OTP_CTRL.h PERI_SPI.h PERI_SYSCTL0.h PERI_SYSCTL1.h PERI_SYSCTL2.h PERI_SYSPLL_T3.h PERI_SYSPLL_TCPU.h PERI_SYSPLL_TDDR.h PERI_TRNG.h PERI_USART.h PERI_USBC.h PERI_USIM.h PERI_UTICK.h PERI_WLAPU.h PERI_WWDT.h
  group utilities
    ../../../../../../devices/RW612/utilities/debug_console_lite/: fsl_assert.h fsl_assert.c
  group utilities/str
    ../../../../../../devices/RW612/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console_lite
    ../../../../../../devices/RW612/utilities/debug_console_lite/: fsl_debug_console.h fsl_debug_console.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/els_pkc/src/comps/mcuxClBuffer/src
    ../../../../../../components/els_pkc/src/comps/mcuxClBuffer/src/: mcuxClBuffer.c
  group component/els_pkc/src/comps/mcuxClBuffer/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClBuffer/inc/: mcuxClBuffer.h mcuxClBuffer_Cfg.h mcuxClBuffer_Constants.h mcuxClBuffer_Impl.h mcuxClBuffer_Pointer.h
  group component/els_pkc/src/comps/mcuxClBuffer/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClBuffer/inc/internal/: mcuxClBuffer_Internal.h mcuxClBuffer_Internal_Pointer.h
  group component/els_pkc/src/comps/mcuxClCore/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClCore/inc/: mcuxClCore_Examples.h mcuxClCore_FunctionIdentifiers.h mcuxClCore_Macros.h mcuxClCore_Platform.h mcuxClCore_Toolchain.h
  group component/els_pkc/src/comps/mcuxClEls/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClEls/inc/: mcuxClEls.h mcuxClEls_Aead.h mcuxClEls_Cipher.h mcuxClEls_Cmac.h mcuxClEls_Crc.h mcuxClEls_Ecc.h mcuxClEls_Hash.h mcuxClEls_Hmac.h mcuxClEls_Kdf.h mcuxClEls_mapping.h mcuxClEls_Rng.h mcuxClEls_Types.h mcuxClEls_KeyManagement.h mcuxClEls_Common.h mcuxClEls_GlitchDetector.h
  group component/els_pkc/src/comps/mcuxClEls/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClEls/inc/internal/: mcuxClEls_Internal.h mcuxClEls_Internal_mapping.h mcuxClEls_SfrAccess.h mcuxClEls_Internal_Common.h
  group component/els_pkc/src/comps/mcuxClEls/src
    ../../../../../../components/els_pkc/src/comps/mcuxClEls/src/: mcuxClEls_Common.c mcuxClEls_GlitchDetector.c
  group component/els_pkc/src/comps/mcuxClMemory/src
    ../../../../../../components/els_pkc/src/comps/mcuxClMemory/src/: mcuxClMemory.c
  group component/els_pkc/src/comps/mcuxClMemory/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClMemory/inc/: mcuxClMemory.h mcuxClMemory_Clear.h mcuxClMemory_Constants.h mcuxClMemory_Copy.h mcuxClMemory_Copy_Reversed.h mcuxClMemory_Endianness.h mcuxClMemory_Set.h mcuxClMemory_Types.h mcuxClMemory_Xor.h
  group component/els_pkc/src/comps/mcuxClMemory/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClMemory/inc/internal/: mcuxClMemory_Internal.h
  group component/els_pkc/src/comps/mcuxCsslMemory/src
    ../../../../../../components/els_pkc/src/comps/mcuxCsslMemory/src/: mcuxCsslMemory_Clear.c mcuxCsslMemory_Compare.c mcuxCsslMemory_Copy.c mcuxCsslMemory_Set.c
  group component/els_pkc/src/comps/mcuxCsslMemory/inc
    ../../../../../../components/els_pkc/src/comps/mcuxCsslMemory/inc/: mcuxCsslMemory.h mcuxCsslMemory_Clear.h mcuxCsslMemory_Compare.h mcuxCsslMemory_Constants.h mcuxCsslMemory_Copy.h mcuxCsslMemory_Set.h mcuxCsslMemory_Types.h
  group component/els_pkc/src/comps/mcuxCsslMemory/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxCsslMemory/inc/internal/: mcuxCsslMemory_Internal_Compare_asm.h mcuxCsslMemory_Internal_Copy_asm.h
  group component/els_pkc/src/comps/mcuxCsslCPreProcessor/inc
    ../../../../../../components/els_pkc/src/comps/mcuxCsslCPreProcessor/inc/: mcuxCsslAnalysis.h mcuxCsslCPreProcessor.h
  group component/els_pkc/src/comps/mcuxCsslDataIntegrity/inc
    ../../../../../../components/els_pkc/src/comps/mcuxCsslDataIntegrity/inc/: mcuxCsslDataIntegrity.h mcuxCsslDataIntegrity_Cfg.h mcuxCsslDataIntegrity_Impl.h mcuxCsslDataIntegrity_None.h
  group component/els_pkc/src/comps/mcuxCsslFlowProtection/inc
    ../../../../../../components/els_pkc/src/comps/mcuxCsslFlowProtection/inc/: mcuxCsslFlowProtection.h mcuxCsslFlowProtection_Cfg.h mcuxCsslFlowProtection_FunctionIdentifiers.h mcuxCsslFlowProtection_Impl.h mcuxCsslFlowProtection_SecureCounter_Common.h mcuxCsslFlowProtection_SecureCounter_Local.h
  group component/els_pkc/src/comps/mcuxCsslParamIntegrity/src
    ../../../../../../components/els_pkc/src/comps/mcuxCsslParamIntegrity/src/: mcuxCsslParamIntegrity32.c
  group component/els_pkc/src/comps/mcuxCsslParamIntegrity/inc
    ../../../../../../components/els_pkc/src/comps/mcuxCsslParamIntegrity/inc/: mcuxCsslParamIntegrity.h
  group component/els_pkc/src/comps/mcuxCsslSecureCounter/inc
    ../../../../../../components/els_pkc/src/comps/mcuxCsslSecureCounter/inc/: mcuxCsslSecureCounter.h mcuxCsslSecureCounter_Cfg.h mcuxCsslSecureCounter_Impl.h mcuxCsslSecureCounter_None.h mcuxCsslSecureCounter_SW_Local.h
  group component/els_pkc/src/compiler
    ../../../../../../components/els_pkc/src/compiler/: mcuxClToolchain.h
  group component/els_pkc/src/platforms/rw61x
    ../../../../../../components/els_pkc/src/platforms/rw61x/: platform_specific_headers.h mcuxClConfig.h
  group component/els_pkc/src/platforms/rw61x/inc
    ../../../../../../components/els_pkc/src/platforms/rw61x/inc/: ip_css_constants.h ip_css_design_configuration.h ip_platform.h
  group component/els_pkc/includes
    ../../../../../../components/els_pkc/includes/: mcuxClEls_GlitchDetector.h
  group component/els_pkc/includes/platform/rw61x
    ../../../../../../components/els_pkc/includes/platform/rw61x/: mcuxClAeadModes_MemoryConsumption.h mcuxClCipherModes_MemoryConsumption.h mcuxClEcc_MemoryConsumption.h mcuxClHashModes_MemoryConsumption.h mcuxClHash_MemoryConsumption.h mcuxClHmac_MemoryConsumption.h mcuxClKey_MemoryConsumption.h mcuxClMacModes_MemoryConsumption.h mcuxClRandomModes_MemoryConsumption.h mcuxClRsa_MemoryConsumption.h mcuxClSession_MemoryConsumption.h
  group component/conn_fwloader/include
    ../../../../../../components/conn_fwloader/include/: fsl_loader.h
  group tf-m/platform/ext/target/nxp/common
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/: target_cfg_common.h libc_dummy.c tfm_hal_ns_init.c
  group tf-m/platform/ext/target/nxp/common/Device/Include
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/Device/Include/: cmsis.h device_definition.h platform_irq.h platform_regs.h
  group tf-m/platform/ext/target/nxp/common/Device/Config
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/Device/Config/: device_cfg.h
  group tf-m/platform/ext/target/nxp/common/CMSIS_Driver
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/common/CMSIS_Driver/: Driver_USART.c
  group tf-m/platform/ext/target/nxp/frdmrw612
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/frdmrw612/: platform_psa_hw_accel.h config_tfm_target.h target_cfg.h tfm_peripherals_def.h
  group tf-m/platform/ext/target/nxp/frdmrw612/Device/Include
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/frdmrw612/Device/Include/: platform_base_address.h
  group tf-m/platform/ext/target/nxp/frdmrw612/Device/Source
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/frdmrw612/Device/Source/: startup_frdmrw612.c
  group tf-m/platform/ext/target/nxp/frdmrw612/partition
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/frdmrw612/partition/: region_defs.h flash_layout.h
  group tf-m/platform/ext/target/nxp/rw61x/platform/include
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/rw61x/platform/include/: platform_nv_counters_ids.h
  group tf-m/platform/ext/target/nxp/rw61x/partitions/loader_service
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/rw61x/partitions/loader_service/: tfm_lds_sid.h tfm_lds_func_ids.h
  group tf-m/platform/ext/target/nxp/rw61x/partitions/loader_service/interface/include
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/rw61x/partitions/loader_service/interface/include/: tfm_lds_defs.h
  group tf-m/platform/ext/target/nxp/rw61x/partitions/loader_service/interface/src
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/rw61x/partitions/loader_service/interface/src/: tfm_lds_api.c
  group tf-m/platform/ext/target/nxp/rw61x/plat_iak_pk
    ../../../../../../middleware/tfm/tf-m/platform/ext/target/nxp/rw61x/plat_iak_pk/: plat_iak_pk.c plat_iak_pk.h
  group tf-m/platform/ext/driver
    ../../../../../../middleware/tfm/tf-m/platform/ext/driver/: Driver_Common.h Driver_Flash.h Driver_MPC.h Driver_PPC.h Driver_USART.h Driver_USART.h Driver_Common.h
  group tf-m/platform/ext/common
    ../../../../../../middleware/tfm/tf-m/platform/ext/common/: uart_stdout.h uart_stdout.c
  group tf-m/platform/include
    ../../../../../../middleware/tfm/tf-m/platform/include/: tfm_plat_crypto_keys.h tfm_hal_device_header.h tfm_plat_boot_seed.h tfm_plat_device_id.h tfm_plat_defs.h tfm_plat_ns.h region.h tfm_plat_test.h
  group tf-m/interface/include
    ../../../../../../middleware/tfm/tf-m/interface/include/: tfm_attest_defs.h config_impl.h tfm_crypto_defs.h tfm_its_defs.h tfm_ps_defs.h tfm_veneers.h tfm_ns_interface.h tfm_psa_call_pack.h tfm_ns_client_ext.h tfm_platform_api.h
  group tf-m/interface/include/crypto_keys
    ../../../../../../middleware/tfm/tf-m/interface/include/crypto_keys/: tfm_builtin_key_ids.h
  group tf-m/interface/include/psa_manifest
    ../../../../../../middleware/tfm/tf-m/interface/include/psa_manifest/: sid.h
  group tf-m/interface/include/os_wrapper
    ../../../../../../middleware/tfm/tf-m/interface/include/os_wrapper/: common.h mutex.h
  group tf-m/interface/include/psa
    ../../../../../../middleware/tfm/tf-m/interface/include/psa/: client.h crypto.h crypto_compat.h crypto_extra.h crypto_platform.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h error.h framework_feature.h initial_attestation.h internal_trusted_storage.h lifecycle.h protected_storage.h service.h storage_common.h
  group tf-m/interface/src
    ../../../../../../middleware/tfm/tf-m/interface/src/: tfm_crypto_api.c tfm_attest_api.c tfm_its_api.c tfm_ps_api.c tfm_platform_api.c tfm_tz_psa_ns_api.c
  group tf-m/interface/src/os_wrapper
    ../../../../../../middleware/tfm/tf-m/interface/src/os_wrapper/: tfm_ns_interface_rtos.c
  group tf-m/secure_fw/spm/include
    ../../../../../../middleware/tfm/tf-m/secure_fw/spm/include/: tfm_arch.h tfm_arch_v8m.h utilities.h
  group tf-m/secure_fw/include
    ../../../../../../middleware/tfm/tf-m/secure_fw/include/: config_tfm.h
  group tf-m/secure_fw/partitions/crypto
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/crypto/: config_crypto_check.h
  group tf-m/secure_fw/partitions/protected_storage
    ../../../../../../middleware/tfm/tf-m/secure_fw/partitions/protected_storage/: config_ps_check.h
  group tf-m/config
    ../../../../../../middleware/tfm/tf-m/config/: config_base.h
  group tf-m/lib/ext/t_cose/inc
    ../../../../../../middleware/tfm/tf-m/lib/ext/t_cose/inc/: t_cose_sign1_sign.h t_cose_common.h
  group mbedtls3x/include/psa
    ../../../../../../middleware/mbedtls3x/include/psa/: crypto_config.h
  group tfm/tf-m/platform/include
    ../../../../../../middleware/tfm/tf-m/platform/include/: boot_hal.h cmsis_override.h exception_info.h fatal_error.h mbedtls_entropy_nv_seed_config.h region.h tfm_attest_hal.h tfm_hal_defs.h tfm_hal_device_header.h tfm_hal_interrupt.h tfm_hal_isolation.h tfm_hal_its.h tfm_hal_its_encryption.h tfm_hal_mailbox.h tfm_hal_multi_core.h tfm_hal_platform.h tfm_hal_ps.h tfm_plat_boot_seed.h tfm_plat_config.h tfm_plat_crypto_keys.h tfm_plat_crypto_nv_seed.h tfm_plat_defs.h tfm_plat_device_id.h tfm_plat_ns.h tfm_plat_nv_counters.h tfm_plat_otp.h tfm_plat_provisioning.h tfm_plat_rotpk.h tfm_plat_test.h tfm_platform_system.h
  group tfm/tf-m/interface/include
    ../../../../../../middleware/tfm/tf-m/interface/include/: config_impl.h tfm_attest_defs.h tfm_attest_iat_defs.h tfm_crypto_defs.h tfm_fwu_defs.h tfm_its_defs.h tfm_ns_client_ext.h tfm_ns_interface.h tfm_platform_api.h tfm_ps_defs.h tfm_psa_call_pack.h tfm_veneers.h
  group tfm/tf-m/interface/include/psa_manifest
    ../../../../../../middleware/tfm/tf-m/interface/include/psa_manifest/: sid.h pid.h
  group tfm/tf-m/interface/include/psa
    ../../../../../../middleware/tfm/tf-m/interface/include/psa/: build_info.h client.h crypto.h crypto_adjust_auto_enabled.h crypto_adjust_config_dependencies.h crypto_adjust_config_key_pair_types.h crypto_adjust_config_synonyms.h crypto_builtin_composites.h crypto_builtin_key_derivation.h crypto_builtin_primitives.h crypto_compat.h crypto_driver_common.h crypto_driver_contexts_composites.h crypto_driver_contexts_key_derivation.h crypto_driver_contexts_primitives.h crypto_extra.h crypto_legacy.h crypto_platform.h crypto_se_driver.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h error.h framework_feature.h initial_attestation.h internal_trusted_storage.h lifecycle.h protected_storage.h service.h storage_common.h update.h
  group tfm/tf-m/interface/include/mbedtls
    ../../../../../../middleware/tfm/tf-m/interface/include/mbedtls/: aes.h aria.h asn1.h asn1write.h base64.h bignum.h block_cipher.h build_info.h camellia.h ccm.h chacha20.h chachapoly.h check_config.h cipher.h cmac.h compat-2.x.h config_adjust_legacy_crypto.h config_adjust_legacy_from_psa.h config_adjust_psa_from_legacy.h config_adjust_psa_superset_legacy.h config_adjust_ssl.h config_adjust_x509.h config_psa.h constant_time.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h entropy.h error.h gcm.h hkdf.h hmac_drbg.h lms.h md.h md5.h memory_buffer_alloc.h net_sockets.h nist_kw.h oid.h pem.h pk.h pkcs12.h pkcs5.h pkcs7.h platform.h platform_time.h platform_util.h poly1305.h private_access.h psa_util.h ripemd160.h rsa.h sha1.h sha256.h sha3.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h
  group tfm/tf-m/interface/include/crypto_keys
    ../../../../../../middleware/tfm/tf-m/interface/include/crypto_keys/: tfm_builtin_key_ids.h
  group tfm/tf-m/lib/ext/mbedcrypto/mbedcrypto_config
    ../../../../../../middleware/tfm/tf-m/lib/ext/mbedcrypto/mbedcrypto_config/: tfm_mbedcrypto_config_profile_large_client.h
  group tfm/tf-m/config/profile
    ../../../../../../middleware/tfm/tf-m/config/profile/: config_profile_large.h
  group qcbor/src
    ../../../../../../middleware/tfm/qcbor/src/: ieee754.c ieee754.h qcbor_decode.c qcbor_encode.c UsefulBuf.c
  group qcbor/inc/qcbor
    ../../../../../../middleware/tfm/qcbor/inc/qcbor/: qcbor.h qcbor_common.h qcbor_decode.h qcbor_encode.h qcbor_private.h qcbor_spiffy_decode.h UsefulBuf.h
  group tf-m-tests/app_broker
    ../../../../../../middleware/tfm/tf-m-tests/app_broker/: os_wrapper_cmsis_rtos_v2.c syscalls_stub.c main_ns.c test_app.h
  group tf-m-tests/lib/log
    ../../../../../../middleware/tfm/tf-m-tests/lib/log/: tfm_log.h tfm_log_raw.c tfm_log_raw.h
  group tf-m-tests/lib/os_wrapper
    ../../../../../../middleware/tfm/tf-m-tests/lib/os_wrapper/: delay.h msg_queue.h semaphore.h thread.h tick.h
  group tf-m-tests/lib/nsid_manager
    ../../../../../../middleware/tfm/tf-m-tests/lib/nsid_manager/: tfm_nsid_manager.h tfm_nsid_manager.c tz_shim_layer.c
  group tf-m-tests/tests_psa_arch
    ../../../../../../middleware/tfm/tf-m-tests/tests_psa_arch/: test_app.c
  group api-tests/val
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/val/: test_entry_list.inc test_entry_fn_declare_list.inc
  group api-tests/val/nspe
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/val/nspe/: pal_interfaces_ns.h val_attestation.c val_attestation.h val_crypto.c val_crypto.h val_entry.c val_entry.h val_framework.c val_framework.h val_dispatcher.c val_dispatcher.h val_interfaces.c val_interfaces.h val_peripherals.c val_peripherals.h val_platform.c val_platform.h val_storage.c val_storage.h
  group api-tests/val/common
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/val/common/: val.h val_client_defs.h val_target.c val_target.h
  group api-tests/platform/drivers/nvmem
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/platform/drivers/nvmem/: pal_nvmem.c pal_nvmem.h
  group api-tests/platform/targets/common/nspe
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/platform/targets/common/nspe/: pal_common.h pal_weak.c
  group api-tests/platform/targets/common/nspe/crypto
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/platform/targets/common/nspe/crypto/: pal_crypto_config_check.h pal_crypto_intf.c pal_crypto_intf.h
  group api-tests/platform/targets/common/nspe/initial_attestation
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/platform/targets/common/nspe/initial_attestation/: pal_attestation_crypto.c pal_attestation_crypto.h pal_attestation_eat.h pal_attestation_intf.c pal_attestation_intf.h
  group api-tests/platform/targets/common/nspe/protected_storage
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/platform/targets/common/nspe/protected_storage/: pal_protected_storage_intf.c pal_protected_storage_intf.h
  group api-tests/platform/targets/common/nspe/internal_trusted_storage
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/platform/targets/common/nspe/internal_trusted_storage/: pal_internal_trusted_storage_intf.c pal_internal_trusted_storage_intf.h
  group api-tests/platform/targets/tgt_dev_apis_nxp/nspe
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/platform/targets/tgt_dev_apis_nxp/nspe/: pal_attestation_config.h pal_config.h pal_crypto_config.h pal_driver_intf.c pal_storage_config.h target_database.h target_database.c
  group api-tests/dev_apis/crypto/common
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/common/: test_crypto_common.c test_crypto_common.h
  group api-tests/dev_apis/crypto/test_c001
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c001/: test_c001.c test_c001.h test_entry_c001.c
  group api-tests/dev_apis/crypto/test_c002
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c002/: test_c002.c test_c002.h test_data.h test_entry_c002.c
  group api-tests/dev_apis/crypto/test_c003
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c003/: test_c003.c test_c003.h test_data.h test_entry_c003.c
  group api-tests/dev_apis/crypto/test_c004
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c004/: test_c004.c test_c004.h test_data.h test_entry_c004.c
  group api-tests/dev_apis/crypto/test_c005
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c005/: test_c005.c test_c005.h test_data.h test_entry_c005.c
  group api-tests/dev_apis/crypto/test_c006
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c006/: test_c006.c test_c006.h test_data.h test_entry_c006.c
  group api-tests/dev_apis/crypto/test_c007
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c007/: test_c007.c test_c007.h test_data.h test_entry_c007.c
  group api-tests/dev_apis/crypto/test_c008
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c008/: test_c008.c test_c008.h test_data.h test_entry_c008.c
  group api-tests/dev_apis/crypto/test_c009
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c009/: test_c009.c test_c009.h test_data.h test_entry_c009.c
  group api-tests/dev_apis/crypto/test_c010
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c010/: test_c010.c test_c010.h test_data.h test_entry_c010.c
  group api-tests/dev_apis/crypto/test_c011
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c011/: test_c011.c test_c011.h test_data.h test_entry_c011.c
  group api-tests/dev_apis/crypto/test_c012
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c012/: test_c012.c test_c012.h test_data.h test_entry_c012.c
  group api-tests/dev_apis/crypto/test_c013
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c013/: test_c013.c test_c013.h test_data.h test_entry_c013.c
  group api-tests/dev_apis/crypto/test_c014
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c014/: test_c014.c test_c014.h test_data.h test_entry_c014.c
  group api-tests/dev_apis/crypto/test_c015
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c015/: test_c015.c test_c015.h test_data.h test_entry_c015.c
  group api-tests/dev_apis/crypto/test_c016
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c016/: test_c016.c test_c016.h test_data.h test_entry_c016.c
  group api-tests/dev_apis/crypto/test_c017
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c017/: test_c017.c test_c017.h test_data.h test_entry_c017.c
  group api-tests/dev_apis/crypto/test_c018
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c018/: test_c018.c test_c018.h test_data.h test_entry_c018.c
  group api-tests/dev_apis/crypto/test_c019
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c019/: test_c019.c test_c019.h test_data.h test_entry_c019.c
  group api-tests/dev_apis/crypto/test_c020
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c020/: test_c020.c test_c020.h test_data.h test_entry_c020.c
  group api-tests/dev_apis/crypto/test_c021
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c021/: test_c021.c test_c021.h test_data.h test_entry_c021.c
  group api-tests/dev_apis/crypto/test_c022
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c022/: test_c022.c test_c022.h test_data.h test_entry_c022.c
  group api-tests/dev_apis/crypto/test_c023
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c023/: test_c023.c test_c023.h test_data.h test_entry_c023.c
  group api-tests/dev_apis/crypto/test_c024
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c024/: test_c024.c test_c024.h test_data.h test_entry_c024.c
  group api-tests/dev_apis/crypto/test_c025
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c025/: test_c025.c test_c025.h test_data.h test_entry_c025.c
  group api-tests/dev_apis/crypto/test_c026
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c026/: test_c026.c test_c026.h test_data.h test_entry_c026.c
  group api-tests/dev_apis/crypto/test_c027
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c027/: test_c027.c test_c027.h test_data.h test_entry_c027.c
  group api-tests/dev_apis/crypto/test_c028
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c028/: test_c028.c test_c028.h test_data.h test_entry_c028.c
  group api-tests/dev_apis/crypto/test_c029
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c029/: test_c029.c test_c029.h test_data.h test_entry_c029.c
  group api-tests/dev_apis/crypto/test_c030
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c030/: test_c030.c test_c030.h test_data.h test_entry_c030.c
  group api-tests/dev_apis/crypto/test_c031
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c031/: test_c031.c test_c031.h test_data.h test_entry_c031.c
  group api-tests/dev_apis/crypto/test_c032
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c032/: test_c032.c test_c032.h test_data.h test_entry_c032.c
  group api-tests/dev_apis/crypto/test_c033
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c033/: test_c033.c test_c033.h test_data.h test_entry_c033.c
  group api-tests/dev_apis/crypto/test_c034
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c034/: test_c034.c test_c034.h test_data.h test_entry_c034.c
  group api-tests/dev_apis/crypto/test_c035
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c035/: test_c035.c test_c035.h test_data.h test_entry_c035.c
  group api-tests/dev_apis/crypto/test_c036
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c036/: test_c036.c test_c036.h test_data.h test_entry_c036.c
  group api-tests/dev_apis/crypto/test_c037
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c037/: test_c037.c test_c037.h test_data.h test_entry_c037.c
  group api-tests/dev_apis/crypto/test_c038
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c038/: test_c038.c test_c038.h test_data.h test_entry_c038.c
  group api-tests/dev_apis/crypto/test_c039
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c039/: test_c039.c test_c039.h test_data.h test_entry_c039.c
  group api-tests/dev_apis/crypto/test_c040
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c040/: test_c040.c test_c040.h test_data.h test_entry_c040.c
  group api-tests/dev_apis/crypto/test_c041
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c041/: test_c041.c test_c041.h test_data.h test_entry_c041.c
  group api-tests/dev_apis/crypto/test_c042
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c042/: test_c042.c test_c042.h test_data.h test_entry_c042.c
  group api-tests/dev_apis/crypto/test_c043
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c043/: test_c043.c test_c043.h test_data.h test_entry_c043.c
  group api-tests/dev_apis/crypto/test_c044
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c044/: test_c044.c test_c044.h test_data.h test_entry_c044.c
  group api-tests/dev_apis/crypto/test_c045
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c045/: test_c045.c test_c045.h test_data.h test_entry_c045.c
  group api-tests/dev_apis/crypto/test_c046
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c046/: test_c046.c test_c046.h test_data.h test_entry_c046.c
  group api-tests/dev_apis/crypto/test_c047
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c047/: test_c047.c test_c047.h test_data.h test_entry_c047.c
  group api-tests/dev_apis/crypto/test_c048
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c048/: test_c048.c test_c048.h test_data.h test_entry_c048.c
  group api-tests/dev_apis/crypto/test_c049
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c049/: test_c049.c test_c049.h test_data.h test_entry_c049.c
  group api-tests/dev_apis/crypto/test_c050
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c050/: test_c050.c test_c050.h test_data.h test_entry_c050.c
  group api-tests/dev_apis/crypto/test_c051
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c051/: test_c051.c test_c051.h test_data.h test_entry_c051.c
  group api-tests/dev_apis/crypto/test_c052
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c052/: test_c052.c test_c052.h test_data.h test_entry_c052.c
  group api-tests/dev_apis/crypto/test_c053
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c053/: test_c053.c test_c053.h test_data.h test_entry_c053.c
  group api-tests/dev_apis/crypto/test_c054
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c054/: test_c054.c test_c054.h test_data.h test_entry_c054.c
  group api-tests/dev_apis/crypto/test_c055
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c055/: test_c055.c test_c055.h test_data.h test_entry_c055.c
  group api-tests/dev_apis/crypto/test_c056
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c056/: test_c056.c test_c056.h test_data.h test_entry_c056.c
  group api-tests/dev_apis/crypto/test_c057
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c057/: test_c057.c test_c057.h test_data.h test_entry_c057.c
  group api-tests/dev_apis/crypto/test_c058
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c058/: test_c058.c test_c058.h test_data.h test_entry_c058.c
  group api-tests/dev_apis/crypto/test_c059
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c059/: test_c059.c test_c059.h test_data.h test_entry_c059.c
  group api-tests/dev_apis/crypto/test_c060
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c060/: test_c060.c test_c060.h test_data.h test_entry_c060.c
  group api-tests/dev_apis/crypto/test_c061
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/crypto/test_c061/: test_c061.c test_c061.h test_data.h test_entry_c061.c
  group api-tests/dev_apis/initial_attestation/test_a001
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/initial_attestation/test_a001/: test_a001.c test_a001.h test_data.h test_entry_a001.c
  group api-tests/dev_apis/storage
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/: test_storage_common.h test_storage_common.h
  group api-tests/dev_apis/storage/test_s001
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s001/: test_s001.c test_s001.h test_data.h test_entry_s001.c test_s001.c test_s001.h test_data.h test_entry_s001.c
  group api-tests/dev_apis/storage/test_s002
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s002/: test_s002.c test_s002.h test_data.h test_entry_s002.c test_s002.c test_s002.h test_data.h test_entry_s002.c
  group api-tests/dev_apis/storage/test_s003
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s003/: test_s003.c test_s003.h test_data.h test_entry_s003.c test_s003.c test_s003.h test_data.h test_entry_s003.c
  group api-tests/dev_apis/storage/test_s004
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s004/: test_s004.c test_s004.h test_data.h test_entry_s004.c test_s004.c test_s004.h test_data.h test_entry_s004.c
  group api-tests/dev_apis/storage/test_s005
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s005/: test_s005.c test_s005.h test_data.h test_entry_s005.c test_s005.c test_s005.h test_data.h test_entry_s005.c
  group api-tests/dev_apis/storage/test_s006
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s006/: test_s006.c test_s006.h test_data.h test_entry_s006.c test_s006.c test_s006.h test_data.h test_entry_s006.c
  group api-tests/dev_apis/storage/test_s007
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s007/: test_s007.c test_s007.h test_data.h test_entry_s007.c test_s007.c test_s007.h test_data.h test_entry_s007.c
  group api-tests/dev_apis/storage/test_s008
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s008/: test_s008.c test_s008.h test_data.h test_entry_s008.c test_s008.c test_s008.h test_data.h test_entry_s008.c
  group api-tests/dev_apis/storage/test_s009
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s009/: test_s009.c test_s009.h test_data.h test_entry_s009.c test_s009.c test_s009.h test_data.h test_entry_s009.c
  group api-tests/dev_apis/storage/test_s010
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s010/: test_s010.c test_s010.h test_data.h test_entry_s010.c test_s010.c test_s010.h test_data.h test_entry_s010.c
  group api-tests/dev_apis/storage/test_s011
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s011/: test_s011.c test_s011.h test_data.h test_entry_s011.c
  group api-tests/dev_apis/storage/test_s012
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s012/: test_s012.c test_s012.h test_data.h test_entry_s012.c
  group api-tests/dev_apis/storage/test_s013
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s013/: test_s013.c test_s013.h test_data.h test_entry_s013.c
  group api-tests/dev_apis/storage/test_s014
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s014/: test_s014.c test_s014.h test_data.h test_entry_s014.c
  group api-tests/dev_apis/storage/test_s015
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s015/: test_s015.c test_s015.h test_data.h test_entry_s015.c
  group api-tests/dev_apis/storage/test_s016
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s016/: test_s016.c test_s016.h test_data.h test_entry_s016.c
  group api-tests/dev_apis/storage/test_s017
    ../../../../../../middleware/tfm/psa-arch-tests/api-tests/dev_apis/storage/test_s017/: test_s017.c test_s017.h test_data.h test_entry_s017.c
  group source
    ../: mcux_config.h mcux_config.h mcux_config.h mcuxsdk_version.h
