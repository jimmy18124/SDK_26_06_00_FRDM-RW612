<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>enet_txrx_ptp1588_xfer</project>
        <configuration>flash_debug</configuration>
      </member>
      <member>
        <project>enet_txrx_ptp1588_xfer</project>
        <configuration>flash_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flash_debug</name>
      <member>
        <project>enet_txrx_ptp1588_xfer</project>
        <configuration>flash_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flash_release</name>
      <member>
        <project>enet_txrx_ptp1588_xfer</project>
        <configuration>flash_release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/enet_txrx_ptp1588_xfer.ewp</path>
  </project>
</workspace>
