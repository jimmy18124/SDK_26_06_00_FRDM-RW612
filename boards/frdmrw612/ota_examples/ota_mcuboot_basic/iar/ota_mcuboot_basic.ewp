# IAR project ota_mcuboot_basic.ewp, settings and files
configuration flash_debug (ARM, debug)
  General.OGChipSelectEditMenu: RW612 NXP RW612
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; PRINTF_ADVANCED_ENABLE=1; SHELL_PRINT_COPYRIGHT=0; MCUBOOT_OTA_SB3_SUPPORT; ENCRYPTED_XIP_IPED; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_RW612ETA2I; RW612_SERIES; BOOT_HEADER_ENABLE=1; SERIAL_PORT_TYPE_UART=1; MFLASH_FILE_BASEADDR=7340032
  ICCARM.IExtraOptions: --preinclude ../mcuxsdk_version.h --diag_suppress=Pe257  --diag_suppress=Pe111,Pe177,Pe550  --diag_suppress=Pa082,Pa050 --diag_suppress=Pa082,Pa050
  ICCARM.PreInclude: ../mcux_config.h
  ICCARM.CCIncludePath2: ..; ../../../flash_config; ../../../../../devices/RW612/drivers; ../../../../../devices/RW612/drivers/romapi/bootloader; ../../../../../devices/RW612/drivers/romapi/flexspi; ../../../../../devices/RW612/drivers/romapi/iap; ../../../../../devices/RW612/drivers/romapi/nboot; ../../../../../devices/RW612/drivers/romapi/otp; ../../../../../CMSIS/Core/Include; ../../../../../CMSIS/Core/Include/m-profile; ../../../../../devices/RW612; ../../../../../devices/RW612/periph; ../../../../../devices/RW612/utilities/debug_console; ../../../../../components/lists; ../../../../../devices/RW612/utilities/str; ../../../../../devices/RW612/utilities/shell; ../../../../../components/serial_manager; ../../../../../components/uart; ../../../../../components/els_pkc; ../../../../../components/els_pkc/src/comps/mcuxClBuffer/inc; ../../../../../components/els_pkc/src/comps/mcuxClBuffer/inc/internal; ../../../../../components/els_pkc/src/comps/mcuxClCore/inc; ../../../../../components/els_pkc/src/comps/mcuxClEls/inc; ../../../../../components/els_pkc/src/comps/mcuxClEls/inc/internal; ../../../../../components/els_pkc/src/comps/mcuxClMemory/inc; ../../../../../components/els_pkc/src/comps/mcuxClMemory/inc/internal; ../../../../../components/els_pkc/src/comps/mcuxCsslMemory/inc; ../../../../../components/els_pkc/src/comps/mcuxCsslMemory/inc/internal; ../../../../../components/els_pkc/src/comps/mcuxCsslCPreProcessor/inc; ../../../../../components/els_pkc/src/comps/mcuxCsslDataIntegrity/inc; ../../../../../components/els_pkc/src/comps/mcuxCsslFlowProtection/inc; ../../../../../components/els_pkc/src/comps/mcuxCsslParamIntegrity/inc; ../../../../../components/els_pkc/src/comps/mcuxCsslSecureCounter/inc; ../../../../../components/els_pkc/src/compiler; ../../../../../components/els_pkc/src/platforms/rw61x; ../../../../../components/els_pkc/src/platforms/rw61x/inc; ../../../../../components/els_pkc/includes/platform/rw61x; ../../../../../components/flash/mflash; ../../../../../components/flash/mflash/frdmrw612; ../../../../../middleware/mcuboot_opensource/ext/tinycrypt/lib/include; ../../../../../middleware/mcuboot_opensource/boot/nxp_mcux_sdk/encrypted_xip/include; ../../../../../middleware/mcuboot_opensource/boot/nxp_mcux_sdk/app_support; ../../../../../middleware/mcuboot_opensource/boot/nxp_mcux_sdk/include; ../../../../../middleware/mcuboot_opensource/boot/nxp_mcux_sdk/include/mcuboot_config; ../../../../../middleware/mcuboot_opensource/boot/nxp_mcux_sdk
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: MCUXPRESSO_SDK; CPU_RW612ETA2I; RW612_SERIES
  AARM.AUserIncludes: as above
  AARM.PreInclude: ../mcux_config.h
  ILINK.IlinkOutputFile: ota_mcuboot_basic.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x400
  ILINK.IlinkIcfFile: RW610_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; PRINTF_ADVANCED_ENABLE=1; SHELL_PRINT_COPYRIGHT=0; MCUBOOT_OTA_SB3_SUPPORT; ENCRYPTED_XIP_IPED; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_RW612ETA2I; RW612_SERIES; BOOT_HEADER_ENABLE=1; SERIAL_PORT_TYPE_UART=1; MFLASH_FILE_BASEADDR=7340032
  ICCARM.CCOptLevel: 3
  group source
    ../: ota_mcuboot_basic.c xmodem.c xmodem.h platform_bindings.c platform_bindings.h flash_partitioning.h flash_partitioning.c sblconfig.h sb3_api.h sb3_api_rw61x.c flash_api.c fsl_debug_console_conf.h mcux_config.h mcux_config.h mcux_config.h mcuxsdk_version.h
  group board
    ../: board.h board.c clock_config.h clock_config.c pin_mux.c pin_mux.h hardware_init.c app.h
  group flash_config
    ../../../flash_config/: flash_config.c flash_config.h
  group drivers
    ../../../../../devices/RW612/drivers/: fsl_clock.c fsl_clock.h fsl_i2s_bridge.c fsl_i2s_bridge.h fsl_inputmux_connections.h fsl_io_mux.h fsl_iped.c fsl_iped.h fsl_memory.h fsl_ocotp.c fsl_ocotp.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_cache.c fsl_cache.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_flexcomm.h fsl_flexcomm.c fsl_usart.h fsl_usart.c fsl_flexspi.c fsl_flexspi.h fsl_gpio.h fsl_gpio.c
  group drivers/romapi/bootloader
    ../../../../../devices/RW612/drivers/romapi/bootloader/: fsl_romapi.c fsl_romapi.h
  group drivers/romapi/flexspi
    ../../../../../devices/RW612/drivers/romapi/flexspi/: fsl_romapi_flexspi.c fsl_romapi_flexspi.h
  group drivers/romapi/iap
    ../../../../../devices/RW612/drivers/romapi/iap/: fsl_kb_api.h fsl_romapi_iap.c fsl_romapi_iap.h fsl_sbloader_v3.h
  group drivers/romapi/nboot
    ../../../../../devices/RW612/drivers/romapi/nboot/: fsl_romapi_nboot.c fsl_romapi_nboot.h
  group drivers/romapi/otp
    ../../../../../devices/RW612/drivers/romapi/otp/: fsl_romapi_otp.c fsl_romapi_otp.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    ../../../../../CMSIS/Core/Include/m-profile/: cmsis_iccarm_m.h armv8m_mpu.h
  group device
    ../../../../../devices/RW612/: fsl_device_registers.h RW612.h RW612_features.h RW612_COMMON.h system_RW612.c system_RW612.h
  group device/periph
    ../../../../../devices/RW612/periph/: PERI_ACOMP.h PERI_ADC.h PERI_AHB_SECURE_CTRL.h PERI_AON_SOC_CIU.h PERI_APU.h PERI_BG.h PERI_BLEAPU.h PERI_BUCK11.h PERI_BUCK18.h PERI_CACHE64_CTRL.h PERI_CACHE64_POLSEL.h PERI_CAU.h PERI_CDOG.h PERI_CIU1.h PERI_CIU2.h PERI_CLKCTL0.h PERI_CLKCTL1.h PERI_CRC.h PERI_CTIMER.h PERI_DAC.h PERI_DBGMAILBOX.h PERI_DMA.h PERI_DMIC.h PERI_ELS.h PERI_ENET.h PERI_FLEXCOMM.h PERI_FLEXSPI.h PERI_FREQME.h PERI_GDMA.h PERI_GPIO.h PERI_I2C.h PERI_I2S.h PERI_INPUTMUX.h PERI_ITRC.h PERI_LCDIC.h PERI_MCI_IO_MUX.h PERI_MRT.h PERI_OCOTP.h PERI_OSTIMER.h PERI_PINT.h PERI_PKC.h PERI_PMU.h PERI_POWERQUAD.h PERI_PUF.h PERI_RF_SYSCON.h PERI_ROMCP.h PERI_RSTCTL0.h PERI_RSTCTL1.h PERI_RTC.h PERI_SCT.h PERI_SDU_FBR_CARD.h PERI_SDU_FN0_CARD.h PERI_SDU_FN_CARD.h PERI_SENSOR_CTRL.h PERI_SOCCIU.h PERI_SOC_OTP_CTRL.h PERI_SPI.h PERI_SYSCTL0.h PERI_SYSCTL1.h PERI_SYSCTL2.h PERI_SYSPLL_T3.h PERI_SYSPLL_TCPU.h PERI_SYSPLL_TDDR.h PERI_TRNG.h PERI_USART.h PERI_USBC.h PERI_USIM.h PERI_UTICK.h PERI_WLAPU.h PERI_WWDT.h
  group startup/iar
    ../../../../../devices/RW612/iar/: startup_RW612.s
  group utilities
    ../../../../../devices/RW612/utilities/debug_console/: fsl_assert.h fsl_assert.c
    ../../../../../devices/RW612/utilities/shell/: fsl_shell.h fsl_shell.c
  group utilities/str
    ../../../../../devices/RW612/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console
    ../../../../../devices/RW612/utilities/debug_console/: fsl_debug_console.h fsl_debug_console.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/els_pkc/src/comps/mcuxClBuffer/src
    ../../../../../components/els_pkc/src/comps/mcuxClBuffer/src/: mcuxClBuffer.c
  group component/els_pkc/src/comps/mcuxClBuffer/inc
    ../../../../../components/els_pkc/src/comps/mcuxClBuffer/inc/: mcuxClBuffer.h mcuxClBuffer_Cfg.h mcuxClBuffer_Constants.h mcuxClBuffer_Impl.h mcuxClBuffer_Pointer.h
  group component/els_pkc/src/comps/mcuxClBuffer/inc/internal
    ../../../../../components/els_pkc/src/comps/mcuxClBuffer/inc/internal/: mcuxClBuffer_Internal.h mcuxClBuffer_Internal_Pointer.h
  group component/els_pkc/src/comps/mcuxClCore/inc
    ../../../../../components/els_pkc/src/comps/mcuxClCore/inc/: mcuxClCore_Examples.h mcuxClCore_FunctionIdentifiers.h mcuxClCore_Macros.h mcuxClCore_Platform.h mcuxClCore_Toolchain.h
  group component/els_pkc/src/comps/mcuxClEls/inc
    ../../../../../components/els_pkc/src/comps/mcuxClEls/inc/: mcuxClEls.h mcuxClEls_Aead.h mcuxClEls_Cipher.h mcuxClEls_Cmac.h mcuxClEls_Crc.h mcuxClEls_Ecc.h mcuxClEls_Hash.h mcuxClEls_Hmac.h mcuxClEls_Kdf.h mcuxClEls_mapping.h mcuxClEls_Rng.h mcuxClEls_Types.h mcuxClEls_KeyManagement.h mcuxClEls_Common.h mcuxClEls_GlitchDetector.h
  group component/els_pkc/src/comps/mcuxClEls/inc/internal
    ../../../../../components/els_pkc/src/comps/mcuxClEls/inc/internal/: mcuxClEls_Internal.h mcuxClEls_Internal_mapping.h mcuxClEls_SfrAccess.h mcuxClEls_Internal_Common.h
  group component/els_pkc/src/comps/mcuxClEls/src
    ../../../../../components/els_pkc/src/comps/mcuxClEls/src/: mcuxClEls_Common.c mcuxClEls_GlitchDetector.c
  group component/els_pkc/src/comps/mcuxClMemory/src
    ../../../../../components/els_pkc/src/comps/mcuxClMemory/src/: mcuxClMemory.c
  group component/els_pkc/src/comps/mcuxClMemory/inc
    ../../../../../components/els_pkc/src/comps/mcuxClMemory/inc/: mcuxClMemory.h mcuxClMemory_Clear.h mcuxClMemory_Constants.h mcuxClMemory_Copy.h mcuxClMemory_Copy_Reversed.h mcuxClMemory_Endianness.h mcuxClMemory_Set.h mcuxClMemory_Types.h mcuxClMemory_Xor.h
  group component/els_pkc/src/comps/mcuxClMemory/inc/internal
    ../../../../../components/els_pkc/src/comps/mcuxClMemory/inc/internal/: mcuxClMemory_Internal.h
  group component/els_pkc/src/comps/mcuxCsslMemory/src
    ../../../../../components/els_pkc/src/comps/mcuxCsslMemory/src/: mcuxCsslMemory_Clear.c mcuxCsslMemory_Compare.c mcuxCsslMemory_Copy.c mcuxCsslMemory_Set.c
  group component/els_pkc/src/comps/mcuxCsslMemory/inc
    ../../../../../components/els_pkc/src/comps/mcuxCsslMemory/inc/: mcuxCsslMemory.h mcuxCsslMemory_Clear.h mcuxCsslMemory_Compare.h mcuxCsslMemory_Constants.h mcuxCsslMemory_Copy.h mcuxCsslMemory_Set.h mcuxCsslMemory_Types.h
  group component/els_pkc/src/comps/mcuxCsslMemory/inc/internal
    ../../../../../components/els_pkc/src/comps/mcuxCsslMemory/inc/internal/: mcuxCsslMemory_Internal_Compare_asm.h mcuxCsslMemory_Internal_Copy_asm.h
  group component/els_pkc/src/comps/mcuxCsslCPreProcessor/inc
    ../../../../../components/els_pkc/src/comps/mcuxCsslCPreProcessor/inc/: mcuxCsslAnalysis.h mcuxCsslCPreProcessor.h
  group component/els_pkc/src/comps/mcuxCsslDataIntegrity/inc
    ../../../../../components/els_pkc/src/comps/mcuxCsslDataIntegrity/inc/: mcuxCsslDataIntegrity.h mcuxCsslDataIntegrity_Cfg.h mcuxCsslDataIntegrity_Impl.h mcuxCsslDataIntegrity_None.h
  group component/els_pkc/src/comps/mcuxCsslFlowProtection/inc
    ../../../../../components/els_pkc/src/comps/mcuxCsslFlowProtection/inc/: mcuxCsslFlowProtection.h mcuxCsslFlowProtection_Cfg.h mcuxCsslFlowProtection_FunctionIdentifiers.h mcuxCsslFlowProtection_Impl.h mcuxCsslFlowProtection_SecureCounter_Common.h mcuxCsslFlowProtection_SecureCounter_Local.h
  group component/els_pkc/src/comps/mcuxCsslParamIntegrity/src
    ../../../../../components/els_pkc/src/comps/mcuxCsslParamIntegrity/src/: mcuxCsslParamIntegrity32.c
  group component/els_pkc/src/comps/mcuxCsslParamIntegrity/inc
    ../../../../../components/els_pkc/src/comps/mcuxCsslParamIntegrity/inc/: mcuxCsslParamIntegrity.h
  group component/els_pkc/src/comps/mcuxCsslSecureCounter/inc
    ../../../../../components/els_pkc/src/comps/mcuxCsslSecureCounter/inc/: mcuxCsslSecureCounter.h mcuxCsslSecureCounter_Cfg.h mcuxCsslSecureCounter_Impl.h mcuxCsslSecureCounter_None.h mcuxCsslSecureCounter_SW_Local.h
  group component/els_pkc/src/compiler
    ../../../../../components/els_pkc/src/compiler/: mcuxClToolchain.h
  group component/els_pkc/src/platforms/rw61x
    ../../../../../components/els_pkc/src/platforms/rw61x/: platform_specific_headers.h mcuxClConfig.h
  group component/els_pkc/src/platforms/rw61x/inc
    ../../../../../components/els_pkc/src/platforms/rw61x/inc/: ip_css_constants.h ip_css_design_configuration.h ip_platform.h
  group component/els_pkc/includes
    ../../../../../components/els_pkc/includes/: mcuxClEls_GlitchDetector.h
  group component/els_pkc/includes/platform/rw61x
    ../../../../../components/els_pkc/includes/platform/rw61x/: mcuxClAeadModes_MemoryConsumption.h mcuxClCipherModes_MemoryConsumption.h mcuxClEcc_MemoryConsumption.h mcuxClHashModes_MemoryConsumption.h mcuxClHash_MemoryConsumption.h mcuxClHmac_MemoryConsumption.h mcuxClKey_MemoryConsumption.h mcuxClMacModes_MemoryConsumption.h mcuxClRandomModes_MemoryConsumption.h mcuxClRsa_MemoryConsumption.h mcuxClSession_MemoryConsumption.h
  group flash/mflash
    ../../../../../components/flash/mflash/: mflash_common.h mflash_file.c mflash_file.h
  group flash/mflash/frdmrw612
    ../../../../../components/flash/mflash/frdmrw612/: mflash_drv.c mflash_drv.h
  group tinycrypt/include/tinycrypt
    ../../../../../middleware/mcuboot_opensource/ext/tinycrypt/lib/include/tinycrypt/: aes.h cbc_mode.h ccm_mode.h cmac_mode.h constants.h ctr_mode.h ctr_prng.h ecc.h ecc_dh.h ecc_dsa.h hmac.h hmac_prng.h sha256.h utils.h ecc_platform_specific.h
  group tinycrypt/source
    ../../../../../middleware/mcuboot_opensource/ext/tinycrypt/lib/source/: aes_decrypt.c aes_encrypt.c cbc_mode.c ccm_mode.c cmac_mode.c ctr_mode.c ctr_prng.c ecc.c ecc_dh.c ecc_dsa.c hmac.c hmac_prng.c sha256.c utils.c
  group encrypted_xip/include
    ../../../../../middleware/mcuboot_opensource/boot/nxp_mcux_sdk/encrypted_xip/include/: encrypted_xip.h encrypted_xip_platform.h
  group encrypted_xip/src
    ../../../../../middleware/mcuboot_opensource/boot/nxp_mcux_sdk/encrypted_xip/src/: encrypted_xip.c encrypted_xip_platform_bee.c encrypted_xip_platform_iped.c encrypted_xip_platform_npx.c encrypted_xip_platform_otfad.c
  group bootutil/app_support/app_support
    ../../../../../middleware/mcuboot_opensource/boot/nxp_mcux_sdk/app_support/: mcuboot_app_support.c mcuboot_app_support.h
  group bootutil/app_support/include
    ../../../../../middleware/mcuboot_opensource/boot/nxp_mcux_sdk/include/: flash_map.h
  group bootutil/app_support/include/mcuboot_config
    ../../../../../middleware/mcuboot_opensource/boot/nxp_mcux_sdk/include/mcuboot_config/: mcuboot_config.h
  group bootutil/app_support/include/sysflash
    ../../../../../middleware/mcuboot_opensource/boot/nxp_mcux_sdk/include/sysflash/: sysflash.h
  group doc
    ../: readme.md example_board_readme.md examples_shared_readme.md
