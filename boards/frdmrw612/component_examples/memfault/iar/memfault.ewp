# IAR project memfault.ewp, settings and files
configuration flash_debug (ARM, debug)
  General.OGChipSelectEditMenu: RW612 NXP RW612
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_RW612ETA2I; RW612_SERIES; BOOT_HEADER_ENABLE=1; MFLASH_FILE_BASEADDR=7340032; SDK_OS_FREE_RTOS
  ICCARM.IExtraOptions: --preinclude ../mcuxsdk_version.h --diag_suppress=Pa082,Pa050  --diag_suppress=Pe188,Pe1305,Pe128 --diag_suppress=Pa082,Pa050
  ICCARM.PreInclude: ../mcux_config.h
  ICCARM.CCIncludePath2: ..; ../../../flash_config; ../../../../../devices/RW612/drivers; ../../../../../CMSIS/Core/Include; ../../../../../CMSIS/Core/Include/m-profile; ../../../../../devices/RW612; ../../../../../devices/RW612/periph; ../../../../../devices/RW612/utilities/str; ../../../../../devices/RW612/utilities/debug_console_lite; ../../../../../components/uart; ../../../../../components/els_pkc; ../../../../../components/els_pkc/src/comps/mcuxClBuffer/inc; ../../../../../components/els_pkc/src/comps/mcuxClBuffer/inc/internal; ../../../../../components/els_pkc/src/comps/mcuxClCore/inc; ../../../../../components/els_pkc/src/comps/mcuxClEls/inc; ../../../../../components/els_pkc/src/comps/mcuxClEls/inc/internal; ../../../../../components/els_pkc/src/comps/mcuxClMemory/inc; ../../../../../components/els_pkc/src/comps/mcuxClMemory/inc/internal; ../../../../../components/els_pkc/src/comps/mcuxCsslMemory/inc; ../../../../../components/els_pkc/src/comps/mcuxCsslMemory/inc/internal; ../../../../../components/els_pkc/src/comps/mcuxCsslCPreProcessor/inc; ../../../../../components/els_pkc/src/comps/mcuxCsslDataIntegrity/inc; ../../../../../components/els_pkc/src/comps/mcuxCsslFlowProtection/inc; ../../../../../components/els_pkc/src/comps/mcuxCsslParamIntegrity/inc; ../../../../../components/els_pkc/src/comps/mcuxCsslSecureCounter/inc; ../../../../../components/els_pkc/src/compiler; ../../../../../components/els_pkc/src/platforms/rw61x; ../../../../../components/els_pkc/src/platforms/rw61x/inc; ../../../../../components/els_pkc/includes/platform/rw61x; ../../../../../components/flash/mflash; ../../../../../components/flash/mflash/frdmrw612; ../../../../../components/debug/memfault/memfault-firmware-sdk/components/include; ../../../../../components/debug/memfault/memfault-firmware-sdk/ports/include; ../../../../../components/debug/memfault/memfault-firmware-sdk; ../../../../../components/debug/memfault/sdk_port/include; ../../../../../rtos/freertos/freertos-kernel-upstream/include; ../../../../../rtos/freertos/freertos-kernel/include; ../../../../../rtos/freertos/freertos-kernel/template; ../../../../../rtos/freertos/freertos-kernel-upstream/portable/IAR/ARM_CM33_NTZ/non_secure
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: MCUXPRESSO_SDK; CPU_RW612ETA2I; RW612_SERIES
  AARM.AUserIncludes: as above
  AARM.PreInclude: ../mcux_config.h
  ILINK.IlinkOutputFile: memfault.out
  ILINK.IlinkConfigDefines: __stack_size__=0x800
  ILINK.IlinkIcfFile: RW612_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_RW612ETA2I; RW612_SERIES; BOOT_HEADER_ENABLE=1; MFLASH_FILE_BASEADDR=7340032; SDK_OS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  group source
    ../: main.c FreeRTOSConfig_frag.h FreeRTOSConfig_Gen.h mcux_config.h mcux_config.h mcux_config.h mcuxsdk_version.h
  group board
    ../: board.h board.c clock_config.h clock_config.c pin_mux.h pin_mux.c hardware_init.c app.h
  group flash_config
    ../../../flash_config/: flash_config.c flash_config.h
  group drivers
    ../../../../../devices/RW612/drivers/: fsl_clock.c fsl_clock.h fsl_i2s_bridge.c fsl_i2s_bridge.h fsl_inputmux_connections.h fsl_io_mux.h fsl_iped.c fsl_iped.h fsl_memory.h fsl_ocotp.c fsl_ocotp.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_cache.c fsl_cache.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_flexcomm.h fsl_flexcomm.c fsl_usart.h fsl_usart.c fsl_flexspi.c fsl_flexspi.h fsl_gpio.h fsl_gpio.c
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    ../../../../../CMSIS/Core/Include/m-profile/: cmsis_iccarm_m.h armv8m_mpu.h
  group device
    ../../../../../devices/RW612/: fsl_device_registers.h RW612.h RW612_features.h RW612_COMMON.h system_RW612.c system_RW612.h
  group device/periph
    ../../../../../devices/RW612/periph/: PERI_ACOMP.h PERI_ADC.h PERI_AHB_SECURE_CTRL.h PERI_AON_SOC_CIU.h PERI_APU.h PERI_BG.h PERI_BLEAPU.h PERI_BUCK11.h PERI_BUCK18.h PERI_CACHE64_CTRL.h PERI_CACHE64_POLSEL.h PERI_CAU.h PERI_CDOG.h PERI_CIU1.h PERI_CIU2.h PERI_CLKCTL0.h PERI_CLKCTL1.h PERI_CRC.h PERI_CTIMER.h PERI_DAC.h PERI_DBGMAILBOX.h PERI_DMA.h PERI_DMIC.h PERI_ELS.h PERI_ENET.h PERI_FLEXCOMM.h PERI_FLEXSPI.h PERI_FREQME.h PERI_GDMA.h PERI_GPIO.h PERI_I2C.h PERI_I2S.h PERI_INPUTMUX.h PERI_ITRC.h PERI_LCDIC.h PERI_MCI_IO_MUX.h PERI_MRT.h PERI_OCOTP.h PERI_OSTIMER.h PERI_PINT.h PERI_PKC.h PERI_PMU.h PERI_POWERQUAD.h PERI_PUF.h PERI_RF_SYSCON.h PERI_ROMCP.h PERI_RSTCTL0.h PERI_RSTCTL1.h PERI_RTC.h PERI_SCT.h PERI_SDU_FBR_CARD.h PERI_SDU_FN0_CARD.h PERI_SDU_FN_CARD.h PERI_SENSOR_CTRL.h PERI_SOCCIU.h PERI_SOC_OTP_CTRL.h PERI_SPI.h PERI_SYSCTL0.h PERI_SYSCTL1.h PERI_SYSCTL2.h PERI_SYSPLL_T3.h PERI_SYSPLL_TCPU.h PERI_SYSPLL_TDDR.h PERI_TRNG.h PERI_USART.h PERI_USBC.h PERI_USIM.h PERI_UTICK.h PERI_WLAPU.h PERI_WWDT.h
  group startup/iar
    ../../../../../devices/RW612/iar/: startup_RW612.s
  group utilities/str
    ../../../../../devices/RW612/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console_lite
    ../../../../../devices/RW612/utilities/debug_console_lite/: fsl_debug_console.h fsl_debug_console.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/els_pkc/src/comps/mcuxClBuffer/src
    ../../../../../components/els_pkc/src/comps/mcuxClBuffer/src/: mcuxClBuffer.c
  group component/els_pkc/src/comps/mcuxClBuffer/inc
    ../../../../../components/els_pkc/src/comps/mcuxClBuffer/inc/: mcuxClBuffer.h mcuxClBuffer_Cfg.h mcuxClBuffer_Constants.h mcuxClBuffer_Impl.h mcuxClBuffer_Pointer.h
  group component/els_pkc/src/comps/mcuxClBuffer/inc/internal
    ../../../../../components/els_pkc/src/comps/mcuxClBuffer/inc/internal/: mcuxClBuffer_Internal.h mcuxClBuffer_Internal_Pointer.h
  group component/els_pkc/src/comps/mcuxClCore/inc
    ../../../../../components/els_pkc/src/comps/mcuxClCore/inc/: mcuxClCore_Examples.h mcuxClCore_FunctionIdentifiers.h mcuxClCore_Macros.h mcuxClCore_Platform.h mcuxClCore_Toolchain.h
  group component/els_pkc/src/comps/mcuxClEls/inc
    ../../../../../components/els_pkc/src/comps/mcuxClEls/inc/: mcuxClEls.h mcuxClEls_Aead.h mcuxClEls_Cipher.h mcuxClEls_Cmac.h mcuxClEls_Crc.h mcuxClEls_Ecc.h mcuxClEls_Hash.h mcuxClEls_Hmac.h mcuxClEls_Kdf.h mcuxClEls_mapping.h mcuxClEls_Rng.h mcuxClEls_Types.h mcuxClEls_KeyManagement.h mcuxClEls_Common.h mcuxClEls_GlitchDetector.h
  group component/els_pkc/src/comps/mcuxClEls/inc/internal
    ../../../../../components/els_pkc/src/comps/mcuxClEls/inc/internal/: mcuxClEls_Internal.h mcuxClEls_Internal_mapping.h mcuxClEls_SfrAccess.h mcuxClEls_Internal_Common.h
  group component/els_pkc/src/comps/mcuxClEls/src
    ../../../../../components/els_pkc/src/comps/mcuxClEls/src/: mcuxClEls_Common.c mcuxClEls_GlitchDetector.c
  group component/els_pkc/src/comps/mcuxClMemory/src
    ../../../../../components/els_pkc/src/comps/mcuxClMemory/src/: mcuxClMemory.c
  group component/els_pkc/src/comps/mcuxClMemory/inc
    ../../../../../components/els_pkc/src/comps/mcuxClMemory/inc/: mcuxClMemory.h mcuxClMemory_Clear.h mcuxClMemory_Constants.h mcuxClMemory_Copy.h mcuxClMemory_Copy_Reversed.h mcuxClMemory_Endianness.h mcuxClMemory_Set.h mcuxClMemory_Types.h mcuxClMemory_Xor.h
  group component/els_pkc/src/comps/mcuxClMemory/inc/internal
    ../../../../../components/els_pkc/src/comps/mcuxClMemory/inc/internal/: mcuxClMemory_Internal.h
  group component/els_pkc/src/comps/mcuxCsslMemory/src
    ../../../../../components/els_pkc/src/comps/mcuxCsslMemory/src/: mcuxCsslMemory_Clear.c mcuxCsslMemory_Compare.c mcuxCsslMemory_Copy.c mcuxCsslMemory_Set.c
  group component/els_pkc/src/comps/mcuxCsslMemory/inc
    ../../../../../components/els_pkc/src/comps/mcuxCsslMemory/inc/: mcuxCsslMemory.h mcuxCsslMemory_Clear.h mcuxCsslMemory_Compare.h mcuxCsslMemory_Constants.h mcuxCsslMemory_Copy.h mcuxCsslMemory_Set.h mcuxCsslMemory_Types.h
  group component/els_pkc/src/comps/mcuxCsslMemory/inc/internal
    ../../../../../components/els_pkc/src/comps/mcuxCsslMemory/inc/internal/: mcuxCsslMemory_Internal_Compare_asm.h mcuxCsslMemory_Internal_Copy_asm.h
  group component/els_pkc/src/comps/mcuxCsslCPreProcessor/inc
    ../../../../../components/els_pkc/src/comps/mcuxCsslCPreProcessor/inc/: mcuxCsslAnalysis.h mcuxCsslCPreProcessor.h
  group component/els_pkc/src/comps/mcuxCsslDataIntegrity/inc
    ../../../../../components/els_pkc/src/comps/mcuxCsslDataIntegrity/inc/: mcuxCsslDataIntegrity.h mcuxCsslDataIntegrity_Cfg.h mcuxCsslDataIntegrity_Impl.h mcuxCsslDataIntegrity_None.h
  group component/els_pkc/src/comps/mcuxCsslFlowProtection/inc
    ../../../../../components/els_pkc/src/comps/mcuxCsslFlowProtection/inc/: mcuxCsslFlowProtection.h mcuxCsslFlowProtection_Cfg.h mcuxCsslFlowProtection_FunctionIdentifiers.h mcuxCsslFlowProtection_Impl.h mcuxCsslFlowProtection_SecureCounter_Common.h mcuxCsslFlowProtection_SecureCounter_Local.h
  group component/els_pkc/src/comps/mcuxCsslParamIntegrity/src
    ../../../../../components/els_pkc/src/comps/mcuxCsslParamIntegrity/src/: mcuxCsslParamIntegrity32.c
  group component/els_pkc/src/comps/mcuxCsslParamIntegrity/inc
    ../../../../../components/els_pkc/src/comps/mcuxCsslParamIntegrity/inc/: mcuxCsslParamIntegrity.h
  group component/els_pkc/src/comps/mcuxCsslSecureCounter/inc
    ../../../../../components/els_pkc/src/comps/mcuxCsslSecureCounter/inc/: mcuxCsslSecureCounter.h mcuxCsslSecureCounter_Cfg.h mcuxCsslSecureCounter_Impl.h mcuxCsslSecureCounter_None.h mcuxCsslSecureCounter_SW_Local.h
  group component/els_pkc/src/compiler
    ../../../../../components/els_pkc/src/compiler/: mcuxClToolchain.h
  group component/els_pkc/src/platforms/rw61x
    ../../../../../components/els_pkc/src/platforms/rw61x/: platform_specific_headers.h mcuxClConfig.h
  group component/els_pkc/src/platforms/rw61x/inc
    ../../../../../components/els_pkc/src/platforms/rw61x/inc/: ip_css_constants.h ip_css_design_configuration.h ip_platform.h
  group component/els_pkc/includes
    ../../../../../components/els_pkc/includes/: mcuxClEls_GlitchDetector.h
  group component/els_pkc/includes/platform/rw61x
    ../../../../../components/els_pkc/includes/platform/rw61x/: mcuxClAeadModes_MemoryConsumption.h mcuxClCipherModes_MemoryConsumption.h mcuxClEcc_MemoryConsumption.h mcuxClHashModes_MemoryConsumption.h mcuxClHash_MemoryConsumption.h mcuxClHmac_MemoryConsumption.h mcuxClKey_MemoryConsumption.h mcuxClMacModes_MemoryConsumption.h mcuxClRandomModes_MemoryConsumption.h mcuxClRsa_MemoryConsumption.h mcuxClSession_MemoryConsumption.h
  group component/debug/memfault/memfault-firmware-sdk/components/core/src
    ../../../../../components/debug/memfault/memfault-firmware-sdk/components/core/src/: arch_arm_cortex_m.c memfault_batched_events.c memfault_build_id.c memfault_compact_log_serializer.c memfault_core_utils.c memfault_custom_data_recording.c memfault_data_export.c memfault_data_packetizer.c memfault_data_source_rle.c memfault_event_storage.c memfault_heap_stats.c memfault_log.c memfault_log_data_source.c memfault_ram_reboot_info_tracking.c memfault_reboot_tracking_serializer.c memfault_sdk_assert.c memfault_self_test.c memfault_self_test_utils.c memfault_serializer_helper.c memfault_task_watchdog.c memfault_trace_event.c memfault_build_id_private.h memfault_custom_data_recording_private.h memfault_log_data_source_private.h memfault_log_private.h memfault_reboot_tracking_private.h memfault_self_test_private.h memfault_trace_event_private.h
  group component/debug/memfault/memfault-firmware-sdk/components/panics/src
    ../../../../../components/debug/memfault/memfault-firmware-sdk/components/panics/src/: memfault_coredump.c memfault_coredump_regions_armv7.c memfault_coredump_sdk_regions.c memfault_coredump_storage_debug.c memfault_coredump_utils.c memfault_fault_handling_aarch64.c memfault_fault_handling_arm.c memfault_fault_handling_armv7_a_r.c memfault_fault_handling_riscv.c memfault_fault_handling_xtensa.c memfault_stdlib_assert.c
  group component/debug/memfault/memfault-firmware-sdk/components/util/src
    ../../../../../components/debug/memfault/memfault-firmware-sdk/components/util/src/: memfault_base64.c memfault_chunk_transport.c memfault_circular_buffer.c memfault_crc16_ccitt.c memfault_minimal_cbor.c memfault_rle.c memfault_varint.c
  group component/debug/memfault/memfault-firmware-sdk/components/include/memfault
    ../../../../../components/debug/memfault/memfault-firmware-sdk/components/include/memfault/: components.h config.h default_config.h version.h
  group component/debug/memfault/memfault-firmware-sdk/components/include/memfault/core
    ../../../../../components/debug/memfault/memfault-firmware-sdk/components/include/memfault/core/: arch.h batched_events.h build_info.h compact_log_compile_time_checks.h compact_log_helpers.h compact_log_serializer.h compiler.h compiler_armcc.h compiler_gcc.h compiler_iar.h compiler_ti_arm.h custom_data_recording.h data_export.h data_packetizer.h data_packetizer_source.h data_source_rle.h debug_log.h device_info.h errors.h event_storage.h event_storage_implementation.h heap_stats.h heap_stats_impl.h log.h log_impl.h math.h preprocessor.h reboot_reason_types.h reboot_tracking.h sdk_assert.h self_test.h serializer_helper.h serializer_key_ids.h task_watchdog.h task_watchdog_impl.h trace_event.h trace_event_impl.h trace_reason_user.h
  group component/debug/memfault/memfault-firmware-sdk/components/include/memfault/core/platform
    ../../../../../components/debug/memfault/memfault-firmware-sdk/components/include/memfault/core/platform/: core.h crc32.h debug_log.h device_info.h nonvolatile_event_storage.h overrides.h reboot_tracking.h system_time.h
  group component/debug/memfault/memfault-firmware-sdk/components/include/memfault/panics
    ../../../../../components/debug/memfault/memfault-firmware-sdk/components/include/memfault/panics/: assert.h coredump.h coredump_impl.h fault_handling.h
  group component/debug/memfault/memfault-firmware-sdk/components/include/memfault/panics/platform
    ../../../../../components/debug/memfault/memfault-firmware-sdk/components/include/memfault/panics/platform/: coredump.h
  group component/debug/memfault/memfault-firmware-sdk/components/include/memfault/panics/arch/arm
    ../../../../../components/debug/memfault/memfault-firmware-sdk/components/include/memfault/panics/arch/arm/: aarch64.h cortex_m.h v7_a_r.h
  group component/debug/memfault/memfault-firmware-sdk/components/include/memfault/panics/arch/riscv
    ../../../../../components/debug/memfault/memfault-firmware-sdk/components/include/memfault/panics/arch/riscv/: riscv.h
  group component/debug/memfault/memfault-firmware-sdk/components/include/memfault/panics/arch/xtensa
    ../../../../../components/debug/memfault/memfault-firmware-sdk/components/include/memfault/panics/arch/xtensa/: xtensa.h
  group component/debug/memfault/memfault-firmware-sdk/components/include/memfault/http
    ../../../../../components/debug/memfault/memfault-firmware-sdk/components/include/memfault/http/: http_client.h root_certs.h utils.h
  group component/debug/memfault/memfault-firmware-sdk/components/include/memfault/http/platform
    ../../../../../components/debug/memfault/memfault-firmware-sdk/components/include/memfault/http/platform/: http_client.h
  group component/debug/memfault/memfault-firmware-sdk/components/include/memfault/metrics
    ../../../../../components/debug/memfault/memfault-firmware-sdk/components/include/memfault/metrics/: battery.h connectivity.h ids_impl.h metrics.h reliability.h serializer.h utils.h battery.h connectivity.h ids_impl.h metrics.h reliability.h serializer.h utils.h heartbeat_config.def
  group component/debug/memfault/memfault-firmware-sdk/components/include/memfault/metrics/platform
    ../../../../../components/debug/memfault/memfault-firmware-sdk/components/include/memfault/metrics/platform/: battery.h connectivity.h overrides.h timer.h battery.h connectivity.h overrides.h timer.h
  group component/debug/memfault/memfault-firmware-sdk/components/include/memfault/demo
    ../../../../../components/debug/memfault/memfault-firmware-sdk/components/include/memfault/demo/: cli.h shell.h shell_commands.h util.h
  group component/debug/memfault/memfault-firmware-sdk/components/include/memfault/util
    ../../../../../components/debug/memfault/memfault-firmware-sdk/components/include/memfault/util/: align.h banner.h base64.h cbor.h chunk_transport.h circular_buffer.h crc16.h rle.h varint.h
  group component/debug/memfault/memfault-firmware-sdk/components/metrics/src
    ../../../../../components/debug/memfault/memfault-firmware-sdk/components/metrics/src/: memfault_metrics.c memfault_metrics_battery.c memfault_metrics_connectivity.c memfault_metrics_reliability.c memfault_metrics_serializer.c
  group component/debug/memfault/memfault-firmware-sdk/ports/include/memfault/ports
    ../../../../../components/debug/memfault/memfault-firmware-sdk/ports/include/memfault/ports/: buffered_coredump_storage.h freertos.h freertos_coredump.h freertos_trace.h reboot_reason.h watchdog.h freertos.h freertos_coredump.h freertos_trace.h
  group component/debug/memfault/memfault-firmware-sdk/ports/include/memfault/ports/freertos
    ../../../../../components/debug/memfault/memfault-firmware-sdk/ports/include/memfault/ports/freertos/: metrics.h thread_metrics.h
  group component/debug/memfault/memfault-firmware-sdk/ports/freertos/src
    ../../../../../components/debug/memfault/memfault-firmware-sdk/ports/freertos/src/: memfault_core_freertos.c memfault_freertos_ram_regions.c memfault_metrics_freertos.c memfault_panics_freertos.c memfault_sdk_metrics_freertos.c memfault_sdk_metrics_thread.c memfault_self_test_platform.c
  group component/debug/memfault/memfault-firmware-sdk/ports/freertos/config
    ../../../../../components/debug/memfault/memfault-firmware-sdk/ports/freertos/config/: memfault_metrics_heartbeat_freertos_config.def
  group component/debug/memfault/sdk_port/src
    ../../../../../components/debug/memfault/sdk_port/src/: memfault_platform_flash_backed_coredump.c memfault_platform_port.c
  group component/debug/memfault/sdk_port/include
    ../../../../../components/debug/memfault/sdk_port/include/: memfault_platform_config.h memfault_metrics_heartbeat_config.def memfault_trace_reason_user_config.def
  group flash/mflash
    ../../../../../components/flash/mflash/: mflash_common.h mflash_file.c mflash_file.h
  group flash/mflash/frdmrw612
    ../../../../../components/flash/mflash/frdmrw612/: mflash_drv.c mflash_drv.h
  group freertos/freertos-kernel-upstream
    ../../../../../rtos/freertos/freertos-kernel-upstream/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel-upstream/include
    ../../../../../rtos/freertos/freertos-kernel-upstream/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h
  group freertos/freertos-kernel-upstream/portable
    ../../../../../rtos/freertos/freertos-kernel-upstream/portable/: readme.txt
  group freertos/freertos-kernel-upstream/portable/MemMang
    ../../../../../rtos/freertos/freertos-kernel-upstream/portable/MemMang/: ReadMe.url
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../rtos/freertos/freertos-kernel-upstream/portable/MemMang/: heap_4.c
  group freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure
    ../../../../../rtos/freertos/freertos-kernel-upstream/portable/IAR/ARM_CM33_NTZ/non_secure/: mpu_wrappers_v2_asm.S port.c portasm.h portasm.s portmacro.h portmacrocommon.h
  group freertos/freertos-kernel/template
    ../../../../../rtos/freertos/freertos-kernel/template/: FreeRTOSConfig.h
  group freertos/freertos-kernel/include
    ../../../../../rtos/freertos/freertos-kernel/include/: freertos_tasks_c_additions.h
  group doc
    ../: readme.md example_board_readme.md examples_shared_readme.md
