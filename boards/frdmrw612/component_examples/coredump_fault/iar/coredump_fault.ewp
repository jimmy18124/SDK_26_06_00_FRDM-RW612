# IAR project coredump_fault.ewp, settings and files
configuration flash_debug (ARM, debug)
  General.OGChipSelectEditMenu: RW612 NXP RW612
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_RW612ETA2I; RW612_SERIES; OSA_USED; BOOT_HEADER_ENABLE=1; USE_RTOS=1; MFLASH_FILE_BASEADDR=7340032; SDK_OS_FREE_RTOS
  ICCARM.IExtraOptions: --preinclude ../mcuxsdk_version.h --diag_suppress=Pa082,Pa050  --diag_suppress=Pe111,Pe021,Pe1153,Pe223
  ICCARM.PreInclude: ../mcux_config.h
  ICCARM.CCIncludePath2: ..; ../../../flash_config; ../../../../../devices/RW612/drivers; ../../../../../CMSIS/Core/Include; ../../../../../CMSIS/Core/Include/m-profile; ../../../../../devices/RW612; ../../../../../devices/RW612/periph; ../../../../../devices/RW612/utilities/debug_console_lite; ../../../../../components/lists; ../../../../../devices/RW612/utilities/str; ../../../../../components/uart; ../../../../../components/osa; ../../../../../components/els_pkc; ../../../../../components/els_pkc/src/comps/mcuxClBuffer/inc; ../../../../../components/els_pkc/src/comps/mcuxClBuffer/inc/internal; ../../../../../components/els_pkc/src/comps/mcuxClCore/inc; ../../../../../components/els_pkc/src/comps/mcuxClEls/inc; ../../../../../components/els_pkc/src/comps/mcuxClEls/inc/internal; ../../../../../components/els_pkc/src/comps/mcuxClMemory/inc; ../../../../../components/els_pkc/src/comps/mcuxClMemory/inc/internal; ../../../../../components/els_pkc/src/comps/mcuxCsslMemory/inc; ../../../../../components/els_pkc/src/comps/mcuxCsslMemory/inc/internal; ../../../../../components/els_pkc/src/comps/mcuxCsslCPreProcessor/inc; ../../../../../components/els_pkc/src/comps/mcuxCsslDataIntegrity/inc; ../../../../../components/els_pkc/src/comps/mcuxCsslFlowProtection/inc; ../../../../../components/els_pkc/src/comps/mcuxCsslParamIntegrity/inc; ../../../../../components/els_pkc/src/comps/mcuxCsslSecureCounter/inc; ../../../../../components/els_pkc/src/compiler; ../../../../../components/els_pkc/src/platforms/rw61x; ../../../../../components/els_pkc/src/platforms/rw61x/inc; ../../../../../components/els_pkc/includes/platform/rw61x; ../../../../../components/flash/mflash; ../../../../../components/flash/mflash/frdmrw612; ../../../../../components/debug/coredump; ../../../../../components/gen_hal/zephyr/include; ../../../../../components/gen_hal/zephyr/misc/generated; ../../../../../components/gen_hal/zephyr/misc; ../../../../../components/gen_hal; ../../../../../components/gen_hal/osa/thread; ../../../../../rtos/freertos/freertos-kernel-upstream/include; ../../../../../rtos/freertos/freertos-kernel/include; ../../../../../rtos/freertos/freertos-kernel/template; ../../../../../rtos/freertos/freertos-kernel-upstream/portable/IAR/ARM_CM33_NTZ/non_secure
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: MCUXPRESSO_SDK; CPU_RW612ETA2I; RW612_SERIES; OSA_USED
  AARM.AUserIncludes: as above
  AARM.PreInclude: ../mcux_config.h
  ILINK.IlinkOutputFile: coredump_fault.out
  ILINK.IlinkIcfFile: RW612_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_RW612ETA2I; RW612_SERIES; OSA_USED; BOOT_HEADER_ENABLE=1; USE_RTOS=1; MFLASH_FILE_BASEADDR=7340032; SDK_OS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  group source
    ../: coredump_fault.c IAR_UsageFault.s FreeRTOSConfig_Gen.h ZephyrMap_Gen.h fsl_os_abstraction_config.h mcux_config.h mcux_config.h mcux_config.h mcuxsdk_version.h
  group board
    ../: board.h board.c clock_config.h clock_config.c pin_mux.c pin_mux.h hardware_init.c app.h
  group flash_config
    ../../../flash_config/: flash_config.c flash_config.h
  group drivers
    ../../../../../devices/RW612/drivers/: fsl_clock.c fsl_clock.h fsl_i2s_bridge.c fsl_i2s_bridge.h fsl_inputmux_connections.h fsl_io_mux.h fsl_iped.c fsl_iped.h fsl_memory.h fsl_ocotp.c fsl_ocotp.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_cache.c fsl_cache.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_flexcomm.h fsl_flexcomm.c fsl_usart.h fsl_usart.c fsl_flexspi.c fsl_flexspi.h fsl_gpio.h fsl_gpio.c
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    ../../../../../CMSIS/Core/Include/m-profile/: cmsis_iccarm_m.h armv8m_mpu.h
  group device
    ../../../../../devices/RW612/: fsl_device_registers.h RW612.h RW612_features.h RW612_COMMON.h system_RW612.c system_RW612.h
  group device/periph
    ../../../../../devices/RW612/periph/: PERI_ACOMP.h PERI_ADC.h PERI_AHB_SECURE_CTRL.h PERI_AON_SOC_CIU.h PERI_APU.h PERI_BG.h PERI_BLEAPU.h PERI_BUCK11.h PERI_BUCK18.h PERI_CACHE64_CTRL.h PERI_CACHE64_POLSEL.h PERI_CAU.h PERI_CDOG.h PERI_CIU1.h PERI_CIU2.h PERI_CLKCTL0.h PERI_CLKCTL1.h PERI_CRC.h PERI_CTIMER.h PERI_DAC.h PERI_DBGMAILBOX.h PERI_DMA.h PERI_DMIC.h PERI_ELS.h PERI_ENET.h PERI_FLEXCOMM.h PERI_FLEXSPI.h PERI_FREQME.h PERI_GDMA.h PERI_GPIO.h PERI_I2C.h PERI_I2S.h PERI_INPUTMUX.h PERI_ITRC.h PERI_LCDIC.h PERI_MCI_IO_MUX.h PERI_MRT.h PERI_OCOTP.h PERI_OSTIMER.h PERI_PINT.h PERI_PKC.h PERI_PMU.h PERI_POWERQUAD.h PERI_PUF.h PERI_RF_SYSCON.h PERI_ROMCP.h PERI_RSTCTL0.h PERI_RSTCTL1.h PERI_RTC.h PERI_SCT.h PERI_SDU_FBR_CARD.h PERI_SDU_FN0_CARD.h PERI_SDU_FN_CARD.h PERI_SENSOR_CTRL.h PERI_SOCCIU.h PERI_SOC_OTP_CTRL.h PERI_SPI.h PERI_SYSCTL0.h PERI_SYSCTL1.h PERI_SYSCTL2.h PERI_SYSPLL_T3.h PERI_SYSPLL_TCPU.h PERI_SYSPLL_TDDR.h PERI_TRNG.h PERI_USART.h PERI_USBC.h PERI_USIM.h PERI_UTICK.h PERI_WLAPU.h PERI_WWDT.h
  group startup/iar
    ../../../../../devices/RW612/iar/: startup_RW612.s
  group utilities
    ../../../../../devices/RW612/utilities/debug_console_lite/: fsl_assert.h fsl_assert.c
  group utilities/str
    ../../../../../devices/RW612/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console_lite
    ../../../../../devices/RW612/utilities/debug_console_lite/: fsl_debug_console.h fsl_debug_console.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/osa
    ../../../../../components/osa/: fsl_os_abstraction_free_rtos.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction.h
  group component/els_pkc/src/comps/mcuxClBuffer/src
    ../../../../../components/els_pkc/src/comps/mcuxClBuffer/src/: mcuxClBuffer.c
  group component/els_pkc/src/comps/mcuxClBuffer/inc
    ../../../../../components/els_pkc/src/comps/mcuxClBuffer/inc/: mcuxClBuffer.h mcuxClBuffer_Cfg.h mcuxClBuffer_Constants.h mcuxClBuffer_Impl.h mcuxClBuffer_Pointer.h
  group component/els_pkc/src/comps/mcuxClBuffer/inc/internal
    ../../../../../components/els_pkc/src/comps/mcuxClBuffer/inc/internal/: mcuxClBuffer_Internal.h mcuxClBuffer_Internal_Pointer.h
  group component/els_pkc/src/comps/mcuxClCore/inc
    ../../../../../components/els_pkc/src/comps/mcuxClCore/inc/: mcuxClCore_Examples.h mcuxClCore_FunctionIdentifiers.h mcuxClCore_Macros.h mcuxClCore_Platform.h mcuxClCore_Toolchain.h
  group component/els_pkc/src/comps/mcuxClEls/inc
    ../../../../../components/els_pkc/src/comps/mcuxClEls/inc/: mcuxClEls.h mcuxClEls_Aead.h mcuxClEls_Cipher.h mcuxClEls_Cmac.h mcuxClEls_Crc.h mcuxClEls_Ecc.h mcuxClEls_Hash.h mcuxClEls_Hmac.h mcuxClEls_Kdf.h mcuxClEls_mapping.h mcuxClEls_Rng.h mcuxClEls_Types.h mcuxClEls_KeyManagement.h mcuxClEls_Common.h mcuxClEls_GlitchDetector.h
  group component/els_pkc/src/comps/mcuxClEls/inc/internal
    ../../../../../components/els_pkc/src/comps/mcuxClEls/inc/internal/: mcuxClEls_Internal.h mcuxClEls_Internal_mapping.h mcuxClEls_SfrAccess.h mcuxClEls_Internal_Common.h
  group component/els_pkc/src/comps/mcuxClEls/src
    ../../../../../components/els_pkc/src/comps/mcuxClEls/src/: mcuxClEls_Common.c mcuxClEls_GlitchDetector.c
  group component/els_pkc/src/comps/mcuxClMemory/src
    ../../../../../components/els_pkc/src/comps/mcuxClMemory/src/: mcuxClMemory.c
  group component/els_pkc/src/comps/mcuxClMemory/inc
    ../../../../../components/els_pkc/src/comps/mcuxClMemory/inc/: mcuxClMemory.h mcuxClMemory_Clear.h mcuxClMemory_Constants.h mcuxClMemory_Copy.h mcuxClMemory_Copy_Reversed.h mcuxClMemory_Endianness.h mcuxClMemory_Set.h mcuxClMemory_Types.h mcuxClMemory_Xor.h
  group component/els_pkc/src/comps/mcuxClMemory/inc/internal
    ../../../../../components/els_pkc/src/comps/mcuxClMemory/inc/internal/: mcuxClMemory_Internal.h
  group component/els_pkc/src/comps/mcuxCsslMemory/src
    ../../../../../components/els_pkc/src/comps/mcuxCsslMemory/src/: mcuxCsslMemory_Clear.c mcuxCsslMemory_Compare.c mcuxCsslMemory_Copy.c mcuxCsslMemory_Set.c
  group component/els_pkc/src/comps/mcuxCsslMemory/inc
    ../../../../../components/els_pkc/src/comps/mcuxCsslMemory/inc/: mcuxCsslMemory.h mcuxCsslMemory_Clear.h mcuxCsslMemory_Compare.h mcuxCsslMemory_Constants.h mcuxCsslMemory_Copy.h mcuxCsslMemory_Set.h mcuxCsslMemory_Types.h
  group component/els_pkc/src/comps/mcuxCsslMemory/inc/internal
    ../../../../../components/els_pkc/src/comps/mcuxCsslMemory/inc/internal/: mcuxCsslMemory_Internal_Compare_asm.h mcuxCsslMemory_Internal_Copy_asm.h
  group component/els_pkc/src/comps/mcuxCsslCPreProcessor/inc
    ../../../../../components/els_pkc/src/comps/mcuxCsslCPreProcessor/inc/: mcuxCsslAnalysis.h mcuxCsslCPreProcessor.h
  group component/els_pkc/src/comps/mcuxCsslDataIntegrity/inc
    ../../../../../components/els_pkc/src/comps/mcuxCsslDataIntegrity/inc/: mcuxCsslDataIntegrity.h mcuxCsslDataIntegrity_Cfg.h mcuxCsslDataIntegrity_Impl.h mcuxCsslDataIntegrity_None.h
  group component/els_pkc/src/comps/mcuxCsslFlowProtection/inc
    ../../../../../components/els_pkc/src/comps/mcuxCsslFlowProtection/inc/: mcuxCsslFlowProtection.h mcuxCsslFlowProtection_Cfg.h mcuxCsslFlowProtection_FunctionIdentifiers.h mcuxCsslFlowProtection_Impl.h mcuxCsslFlowProtection_SecureCounter_Common.h mcuxCsslFlowProtection_SecureCounter_Local.h
  group component/els_pkc/src/comps/mcuxCsslParamIntegrity/src
    ../../../../../components/els_pkc/src/comps/mcuxCsslParamIntegrity/src/: mcuxCsslParamIntegrity32.c
  group component/els_pkc/src/comps/mcuxCsslParamIntegrity/inc
    ../../../../../components/els_pkc/src/comps/mcuxCsslParamIntegrity/inc/: mcuxCsslParamIntegrity.h
  group component/els_pkc/src/comps/mcuxCsslSecureCounter/inc
    ../../../../../components/els_pkc/src/comps/mcuxCsslSecureCounter/inc/: mcuxCsslSecureCounter.h mcuxCsslSecureCounter_Cfg.h mcuxCsslSecureCounter_Impl.h mcuxCsslSecureCounter_None.h mcuxCsslSecureCounter_SW_Local.h
  group component/els_pkc/src/compiler
    ../../../../../components/els_pkc/src/compiler/: mcuxClToolchain.h
  group component/els_pkc/src/platforms/rw61x
    ../../../../../components/els_pkc/src/platforms/rw61x/: platform_specific_headers.h mcuxClConfig.h
  group component/els_pkc/src/platforms/rw61x/inc
    ../../../../../components/els_pkc/src/platforms/rw61x/inc/: ip_css_constants.h ip_css_design_configuration.h ip_platform.h
  group component/els_pkc/includes
    ../../../../../components/els_pkc/includes/: mcuxClEls_GlitchDetector.h
  group component/els_pkc/includes/platform/rw61x
    ../../../../../components/els_pkc/includes/platform/rw61x/: mcuxClAeadModes_MemoryConsumption.h mcuxClCipherModes_MemoryConsumption.h mcuxClEcc_MemoryConsumption.h mcuxClHashModes_MemoryConsumption.h mcuxClHash_MemoryConsumption.h mcuxClHmac_MemoryConsumption.h mcuxClKey_MemoryConsumption.h mcuxClMacModes_MemoryConsumption.h mcuxClRandomModes_MemoryConsumption.h mcuxClRsa_MemoryConsumption.h mcuxClSession_MemoryConsumption.h
  group component/debug/coredump
    ../../../../../components/debug/coredump/: coredump_core.c coredump_memory_regions.c coredump_backend_mflash.c coredump.c error_stack_frame.c coredump_internal.h thread_info.c FreeRTOSConfig_debug_coredump.h
  group component/gen_hal/zephyr/include/zephyr_headers
    ../../../../../components/gen_hal/zephyr/include/zephyr_headers/: types.h toolchain.h types.h irq_offload.h sw_isr_table.h fatal_types.h kernel.h kernel_includes.h kernel_structs.h kernel_version.h syscall.h sys_clock.h spinlock.h fatal.h fatal_types.h irq.h
  group component/gen_hal/zephyr/include/zephyr_headers/toolchain
    ../../../../../components/gen_hal/zephyr/include/zephyr_headers/toolchain/: armclang.h common.h gcc.h iar.h llvm.h mwdt.h xcc.h xcc_missing_defs.h zephyr_stdint.h
  group component/gen_hal/zephyr/include/zephyr_headers/linker
    ../../../../../components/gen_hal/zephyr/include/zephyr_headers/linker/: sections.h section_tags.h
  group component/gen_hal/zephyr/include/zephyr_headers/sys
    ../../../../../components/gen_hal/zephyr/include/zephyr_headers/sys/: __assert.h util.h util_internal.h util_internal_is_eq.h util_internal_util_dec.h util_internal_util_inc.h util_internal_util_x2.h util_listify.h util_loops.h util_macro.h time_units.h sys_io.h byteorder.h rb.h atomic.h atomic_types.h atomic_builtin.h dlist.h slist.h list_gen.h sflist.h sys_heap.h printk.h kobject.h iterable_sections.h mem_manage.h mem_stats.h
  group component/gen_hal/zephyr/include/zephyr_headers/sys/internal
    ../../../../../components/gen_hal/zephyr/include/zephyr_headers/sys/internal/: kobject_internal.h
  group component/gen_hal/zephyr/include/zephyr_headers/arch
    ../../../../../components/gen_hal/zephyr/include/zephyr_headers/arch/: cpu.h arch_interface.h syscall.h arch_inlines.h structs.h exception.h
  group component/gen_hal/zephyr/include/zephyr_headers/arch/arm
    ../../../../../components/gen_hal/zephyr/include/zephyr_headers/arch/arm/: syscall.h arch_inlines.h thread.h exception.h irq.h error.h misc.h arch.h nmi.h asm_inline.h asm_inline_gcc.h gdbstub.h structs.h
  group component/gen_hal/zephyr/include/zephyr_headers/arch/arm/cortex_m
    ../../../../../components/gen_hal/zephyr/include/zephyr_headers/arch/arm/cortex_m/: exception.h nvic.h cpu.h memory_map.h
  group component/gen_hal/zephyr/include/zephyr_headers/arch/arm/mpu
    ../../../../../components/gen_hal/zephyr/include/zephyr_headers/arch/arm/mpu/: arm_mpu.h arm_mpu_v7m.h arm_mpu_v8.h nxp_mpu.h
  group component/gen_hal/zephyr/include/zephyr_headers/arch/arm/mmu
    ../../../../../components/gen_hal/zephyr/include/zephyr_headers/arch/arm/mmu/: arm_mmu.h
  group component/gen_hal/zephyr/include/zephyr_headers/arch/common
    ../../../../../components/gen_hal/zephyr/include/zephyr_headers/arch/common/: sys_io.h addr_types.h ffs.h sys_bitops.h
  group component/gen_hal/zephyr/include/zephyr_headers/timing
    ../../../../../components/gen_hal/zephyr/include/zephyr_headers/timing/: types.h
  group component/gen_hal/zephyr/include/zephyr_headers/kernel
    ../../../../../components/gen_hal/zephyr/include/zephyr_headers/kernel/: obj_core.h stats.h thread_stack.h thread.h mm.h
  group component/gen_hal/zephyr/include/zephyr_headers/kernel/mm
    ../../../../../components/gen_hal/zephyr/include/zephyr_headers/kernel/mm/: demand_paging.h
  group component/gen_hal/zephyr/include/zephyr_headers/kernel/internal
    ../../../../../components/gen_hal/zephyr/include/zephyr_headers/kernel/internal/: mm.h smp.h
  group component/gen_hal/zephyr/include/zephyr_headers/app_memory
    ../../../../../components/gen_hal/zephyr/include/zephyr_headers/app_memory/: mem_domain.h
  group component/gen_hal/zephyr/include/zephyr_headers/tracing
    ../../../../../components/gen_hal/zephyr/include/zephyr_headers/tracing/: tracing_macros.h tracing.h tracking.h
  group component/gen_hal/zephyr/include/zephyr_headers/debug
    ../../../../../components/gen_hal/zephyr/include/zephyr_headers/debug/: coredump.h
  group component/gen_hal/zephyr/misc
    ../../../../../components/gen_hal/zephyr/misc/: cmsis_core.h alloca.h
  group component/gen_hal/zephyr/misc/arch/arm
    ../../../../../components/gen_hal/zephyr/misc/arch/arm/: asm_inline_other.h
  group component/gen_hal/zephyr/misc/generated/zephyr
    ../../../../../components/gen_hal/zephyr/misc/generated/zephyr/: syscall_list.h kobj-types-enum.h
  group component/gen_hal/zephyr/misc/generated/zephyr/syscalls
    ../../../../../components/gen_hal/zephyr/misc/generated/zephyr/syscalls/: kobject.h kernel.h demand_paging.h
  group component/gen_hal/sdk_integ
    ../../../../../components/gen_hal/sdk_integ/: errno.h zephyr_mcux_toolchain.h
  group component/gen_hal/osa/thread
    ../../../../../components/gen_hal/osa/thread/: fsl_osa_thread.c fsl_osa_thread.h
  group flash/mflash
    ../../../../../components/flash/mflash/: mflash_common.h mflash_file.c mflash_file.h
  group flash/mflash/frdmrw612
    ../../../../../components/flash/mflash/frdmrw612/: mflash_drv.c mflash_drv.h
  group freertos/freertos-kernel-upstream
    ../../../../../rtos/freertos/freertos-kernel-upstream/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel-upstream/include
    ../../../../../rtos/freertos/freertos-kernel-upstream/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h
  group freertos/freertos-kernel-upstream/portable
    ../../../../../rtos/freertos/freertos-kernel-upstream/portable/: readme.txt
  group freertos/freertos-kernel-upstream/portable/MemMang
    ../../../../../rtos/freertos/freertos-kernel-upstream/portable/MemMang/: ReadMe.url
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../rtos/freertos/freertos-kernel-upstream/portable/MemMang/: heap_4.c
  group freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure
    ../../../../../rtos/freertos/freertos-kernel-upstream/portable/IAR/ARM_CM33_NTZ/non_secure/: mpu_wrappers_v2_asm.S port.c portasm.h portasm.s portmacro.h portmacrocommon.h
  group freertos/freertos-kernel/template
    ../../../../../rtos/freertos/freertos-kernel/template/: FreeRTOSConfig.h
  group freertos/freertos-kernel/include
    ../../../../../rtos/freertos/freertos-kernel/include/: freertos_tasks_c_additions.h
  group doc
    ../: readme.md Save_Memory_Data.png Switch_memorydump.png example_board_readme.md examples_shared_readme.md
