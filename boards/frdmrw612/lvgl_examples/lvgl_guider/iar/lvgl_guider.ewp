# IAR project lvgl_guider.ewp, settings and files
configuration flash_debug (ARM, debug)
  General.OGChipSelectEditMenu: RW612 NXP RW612
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_RW612ETA2I; RW612_SERIES; BOOT_HEADER_ENABLE=1; MCUX_DBI_LEGACY=0; SDK_I2C_BASED_COMPONENT_USED=1; LV_CONF_INCLUDE_SIMPLE=1; SDK_OS_FREE_RTOS
  ICCARM.IExtraOptions: --preinclude ../mcuxsdk_version.h --diag_suppress=Pa082,Pa050  --diag_suppress=Pe257,Pa039,Pe188,Pa089,Pe191,Pe111,Pa093,Pe177,Pe546,Pe236,Pa205,Pe136,Pa084,Pe550,Pe186,Pe170,Pa217
  ICCARM.PreInclude: ../mcux_config.h
  ICCARM.CCIncludePath2: ..; ../generated; ../custom; ../generated/guider_customer_fonts; ../../../flash_config; ../../../../../devices/RW612/drivers; ../../../../../CMSIS/Core/Include; ../../../../../CMSIS/Core/Include/m-profile; ../../../../../CMSIS/Driver/Include; ../../../../../devices/RW612; ../../../../../devices/RW612/periph; ../../../../../devices/RW612/utilities/debug_console_lite; ../../../../../devices/RW612/utilities/str; ../../../../../components/uart; ../../../../../components/els_pkc; ../../../../../components/els_pkc/src/comps/mcuxClBuffer/inc; ../../../../../components/els_pkc/src/comps/mcuxClBuffer/inc/internal; ../../../../../components/els_pkc/src/comps/mcuxClCore/inc; ../../../../../components/els_pkc/src/comps/mcuxClEls/inc; ../../../../../components/els_pkc/src/comps/mcuxClEls/inc/internal; ../../../../../components/els_pkc/src/comps/mcuxClMemory/inc; ../../../../../components/els_pkc/src/comps/mcuxClMemory/inc/internal; ../../../../../components/els_pkc/src/comps/mcuxCsslMemory/inc; ../../../../../components/els_pkc/src/comps/mcuxCsslMemory/inc/internal; ../../../../../components/els_pkc/src/comps/mcuxCsslCPreProcessor/inc; ../../../../../components/els_pkc/src/comps/mcuxCsslDataIntegrity/inc; ../../../../../components/els_pkc/src/comps/mcuxCsslFlowProtection/inc; ../../../../../components/els_pkc/src/comps/mcuxCsslParamIntegrity/inc; ../../../../../components/els_pkc/src/comps/mcuxCsslSecureCounter/inc; ../../../../../components/els_pkc/src/compiler; ../../../../../components/els_pkc/src/platforms/rw61x; ../../../../../components/els_pkc/src/platforms/rw61x/inc; ../../../../../components/els_pkc/includes/platform/rw61x; ../../../../../components/video; ../../../../../components/video/display/dc; ../../../../../components/video/display; ../../../../../components/video/display/dbi; ../../../../../components/video/display/dbi/lcdic; ../../../../../components/video/display/dbi/lpc_spi; ../../../../../components/video/display/dc/dbi; ../../../../../components/touch/gt911; ../../../../../components/touch/ft6x06; ../../../../../components/display/ili9341; ../../../../../components/display/st7796s; ../../../../../middleware/lvgl; ../../../../../middleware/lvgl/template; ../../../../../rtos/freertos/freertos-kernel-upstream/include; ../../../../../rtos/freertos/freertos-kernel/include; ../../../../../rtos/freertos/freertos-kernel/template; ../../../../../rtos/freertos/freertos-kernel-upstream/portable/IAR/ARM_CM33_NTZ/non_secure
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: MCUXPRESSO_SDK; CPU_RW612ETA2I; RW612_SERIES
  AARM.AUserIncludes: ..; ../../../flash_config; ../../../../../devices/RW612/drivers; ../../../../../CMSIS/Core/Include; ../../../../../CMSIS/Core/Include/m-profile; ../../../../../CMSIS/Driver/Include; ../../../../../devices/RW612; ../../../../../devices/RW612/periph; ../../../../../devices/RW612/utilities/debug_console_lite; ../../../../../devices/RW612/utilities/str; ../../../../../components/uart; ../../../../../components/els_pkc; ../../../../../components/els_pkc/src/comps/mcuxClBuffer/inc; ../../../../../components/els_pkc/src/comps/mcuxClBuffer/inc/internal; ../../../../../components/els_pkc/src/comps/mcuxClCore/inc; ../../../../../components/els_pkc/src/comps/mcuxClEls/inc; ../../../../../components/els_pkc/src/comps/mcuxClEls/inc/internal; ../../../../../components/els_pkc/src/comps/mcuxClMemory/inc; ../../../../../components/els_pkc/src/comps/mcuxClMemory/inc/internal; ../../../../../components/els_pkc/src/comps/mcuxCsslMemory/inc; ../../../../../components/els_pkc/src/comps/mcuxCsslMemory/inc/internal; ../../../../../components/els_pkc/src/comps/mcuxCsslCPreProcessor/inc; ../../../../../components/els_pkc/src/comps/mcuxCsslDataIntegrity/inc; ../../../../../components/els_pkc/src/comps/mcuxCsslFlowProtection/inc; ../../../../../components/els_pkc/src/comps/mcuxCsslParamIntegrity/inc; ../../../../../components/els_pkc/src/comps/mcuxCsslSecureCounter/inc; ../../../../../components/els_pkc/src/compiler; ../../../../../components/els_pkc/src/platforms/rw61x; ../../../../../components/els_pkc/src/platforms/rw61x/inc; ../../../../../components/els_pkc/includes/platform/rw61x; ../../../../../components/video; ../../../../../components/video/display/dc; ../../../../../components/video/display; ../../../../../components/video/display/dbi; ../../../../../components/video/display/dbi/lcdic; ../../../../../components/video/display/dbi/lpc_spi; ../../../../../components/video/display/dc/dbi; ../../../../../components/touch/gt911; ../../../../../components/touch/ft6x06; ../../../../../components/display/ili9341; ../../../../../components/display/st7796s; ../../../../../middleware/lvgl; ../../../../../middleware/lvgl/template; ../../../../../rtos/freertos/freertos-kernel-upstream/include; ../../../../../rtos/freertos/freertos-kernel/include; ../../../../../rtos/freertos/freertos-kernel/template; ../../../../../rtos/freertos/freertos-kernel-upstream/portable/IAR/ARM_CM33_NTZ/non_secure
  AARM.PreInclude: ../mcux_config.h
  ILINK.IlinkOutputFile: lvgl_guider.out
  ILINK.IlinkIcfFile: RW612_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_RW612ETA2I; RW612_SERIES; BOOT_HEADER_ENABLE=1; MCUX_DBI_LEGACY=0; SDK_I2C_BASED_COMPONENT_USED=1; LV_CONF_INCLUDE_SIMPLE=1; SDK_OS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  group source
    ../: lvgl_guider.c lv_conf_ext.h lvgl_demo_utils.c lvgl_demo_utils.h lvgl_freertos.c lvgl_freertos.h FreeRTOSConfig_frag.h pin_mux.c pin_mux.h hardware_init.c app.h display_support.h display_support.c lv_conf.h lvgl_support.h lvgl_support.c FreeRTOSConfig_Gen.h mcux_config.h mcux_config.h mcux_config.h mcuxsdk_version.h
  group generated
    ../generated/: gui_guider.c gui_guider.h events_init.c events_init.h setup_scr_screen.c widgets_init.c widgets_init.h
  group generated/guider_customer_fonts
    ../generated/guider_customer_fonts/: guider_customer_fonts.h
  group custom
    ../custom/: custom.c custom.h
  group board
    ../: board.h board.c clock_config.h clock_config.c
  group flash_config
    ../../../flash_config/: flash_config.c flash_config.h
  group drivers
    ../../../../../devices/RW612/drivers/: fsl_clock.c fsl_clock.h fsl_i2s_bridge.c fsl_i2s_bridge.h fsl_inputmux_connections.h fsl_io_mux.h fsl_iped.c fsl_iped.h fsl_memory.h fsl_ocotp.c fsl_ocotp.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_cache.c fsl_cache.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_flexcomm.h fsl_flexcomm.c fsl_usart.h fsl_usart.c fsl_spi_dma.c fsl_spi_dma.h fsl_spi.c fsl_spi.h fsl_i2c.h fsl_i2c.c fsl_flexspi.c fsl_flexspi.h fsl_inputmux.h fsl_inputmux.c fsl_lcdic_dma.c fsl_lcdic_dma.h fsl_lcdic.h fsl_lcdic.c fsl_dma.c fsl_dma.h fsl_gpio.h fsl_gpio.c
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    ../../../../../CMSIS/Core/Include/m-profile/: cmsis_iccarm_m.h armv8m_mpu.h
  group CMSIS_driver/Include
    ../../../../../CMSIS/Driver/Include/: Driver_I2C.h Driver_Common.h
  group device
    ../../../../../devices/RW612/: fsl_device_registers.h RW612.h RW612_features.h RW612_COMMON.h system_RW612.c system_RW612.h
  group device/periph
    ../../../../../devices/RW612/periph/: PERI_ACOMP.h PERI_ADC.h PERI_AHB_SECURE_CTRL.h PERI_AON_SOC_CIU.h PERI_APU.h PERI_BG.h PERI_BLEAPU.h PERI_BUCK11.h PERI_BUCK18.h PERI_CACHE64_CTRL.h PERI_CACHE64_POLSEL.h PERI_CAU.h PERI_CDOG.h PERI_CIU1.h PERI_CIU2.h PERI_CLKCTL0.h PERI_CLKCTL1.h PERI_CRC.h PERI_CTIMER.h PERI_DAC.h PERI_DBGMAILBOX.h PERI_DMA.h PERI_DMIC.h PERI_ELS.h PERI_ENET.h PERI_FLEXCOMM.h PERI_FLEXSPI.h PERI_FREQME.h PERI_GDMA.h PERI_GPIO.h PERI_I2C.h PERI_I2S.h PERI_INPUTMUX.h PERI_ITRC.h PERI_LCDIC.h PERI_MCI_IO_MUX.h PERI_MRT.h PERI_OCOTP.h PERI_OSTIMER.h PERI_PINT.h PERI_PKC.h PERI_PMU.h PERI_POWERQUAD.h PERI_PUF.h PERI_RF_SYSCON.h PERI_ROMCP.h PERI_RSTCTL0.h PERI_RSTCTL1.h PERI_RTC.h PERI_SCT.h PERI_SDU_FBR_CARD.h PERI_SDU_FN0_CARD.h PERI_SDU_FN_CARD.h PERI_SENSOR_CTRL.h PERI_SOCCIU.h PERI_SOC_OTP_CTRL.h PERI_SPI.h PERI_SYSCTL0.h PERI_SYSCTL1.h PERI_SYSCTL2.h PERI_SYSPLL_T3.h PERI_SYSPLL_TCPU.h PERI_SYSPLL_TDDR.h PERI_TRNG.h PERI_USART.h PERI_USBC.h PERI_USIM.h PERI_UTICK.h PERI_WLAPU.h PERI_WWDT.h
  group startup/iar
    ../../../../../devices/RW612/iar/: startup_RW612.s
  group utilities
    ../../../../../devices/RW612/utilities/debug_console_lite/: fsl_assert.h fsl_assert.c
  group utilities/str
    ../../../../../devices/RW612/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console_lite
    ../../../../../devices/RW612/utilities/debug_console_lite/: fsl_debug_console.h fsl_debug_console.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/els_pkc/src/comps/mcuxClBuffer/src
    ../../../../../components/els_pkc/src/comps/mcuxClBuffer/src/: mcuxClBuffer.c
  group component/els_pkc/src/comps/mcuxClBuffer/inc
    ../../../../../components/els_pkc/src/comps/mcuxClBuffer/inc/: mcuxClBuffer.h mcuxClBuffer_Cfg.h mcuxClBuffer_Constants.h mcuxClBuffer_Impl.h mcuxClBuffer_Pointer.h
  group component/els_pkc/src/comps/mcuxClBuffer/inc/internal
    ../../../../../components/els_pkc/src/comps/mcuxClBuffer/inc/internal/: mcuxClBuffer_Internal.h mcuxClBuffer_Internal_Pointer.h
  group component/els_pkc/src/comps/mcuxClCore/inc
    ../../../../../components/els_pkc/src/comps/mcuxClCore/inc/: mcuxClCore_Examples.h mcuxClCore_FunctionIdentifiers.h mcuxClCore_Macros.h mcuxClCore_Platform.h mcuxClCore_Toolchain.h
  group component/els_pkc/src/comps/mcuxClEls/inc
    ../../../../../components/els_pkc/src/comps/mcuxClEls/inc/: mcuxClEls.h mcuxClEls_Aead.h mcuxClEls_Cipher.h mcuxClEls_Cmac.h mcuxClEls_Crc.h mcuxClEls_Ecc.h mcuxClEls_Hash.h mcuxClEls_Hmac.h mcuxClEls_Kdf.h mcuxClEls_mapping.h mcuxClEls_Rng.h mcuxClEls_Types.h mcuxClEls_KeyManagement.h mcuxClEls_Common.h mcuxClEls_GlitchDetector.h
  group component/els_pkc/src/comps/mcuxClEls/inc/internal
    ../../../../../components/els_pkc/src/comps/mcuxClEls/inc/internal/: mcuxClEls_Internal.h mcuxClEls_Internal_mapping.h mcuxClEls_SfrAccess.h mcuxClEls_Internal_Common.h
  group component/els_pkc/src/comps/mcuxClEls/src
    ../../../../../components/els_pkc/src/comps/mcuxClEls/src/: mcuxClEls_Common.c mcuxClEls_GlitchDetector.c
  group component/els_pkc/src/comps/mcuxClMemory/src
    ../../../../../components/els_pkc/src/comps/mcuxClMemory/src/: mcuxClMemory.c
  group component/els_pkc/src/comps/mcuxClMemory/inc
    ../../../../../components/els_pkc/src/comps/mcuxClMemory/inc/: mcuxClMemory.h mcuxClMemory_Clear.h mcuxClMemory_Constants.h mcuxClMemory_Copy.h mcuxClMemory_Copy_Reversed.h mcuxClMemory_Endianness.h mcuxClMemory_Set.h mcuxClMemory_Types.h mcuxClMemory_Xor.h
  group component/els_pkc/src/comps/mcuxClMemory/inc/internal
    ../../../../../components/els_pkc/src/comps/mcuxClMemory/inc/internal/: mcuxClMemory_Internal.h
  group component/els_pkc/src/comps/mcuxCsslMemory/src
    ../../../../../components/els_pkc/src/comps/mcuxCsslMemory/src/: mcuxCsslMemory_Clear.c mcuxCsslMemory_Compare.c mcuxCsslMemory_Copy.c mcuxCsslMemory_Set.c
  group component/els_pkc/src/comps/mcuxCsslMemory/inc
    ../../../../../components/els_pkc/src/comps/mcuxCsslMemory/inc/: mcuxCsslMemory.h mcuxCsslMemory_Clear.h mcuxCsslMemory_Compare.h mcuxCsslMemory_Constants.h mcuxCsslMemory_Copy.h mcuxCsslMemory_Set.h mcuxCsslMemory_Types.h
  group component/els_pkc/src/comps/mcuxCsslMemory/inc/internal
    ../../../../../components/els_pkc/src/comps/mcuxCsslMemory/inc/internal/: mcuxCsslMemory_Internal_Compare_asm.h mcuxCsslMemory_Internal_Copy_asm.h
  group component/els_pkc/src/comps/mcuxCsslCPreProcessor/inc
    ../../../../../components/els_pkc/src/comps/mcuxCsslCPreProcessor/inc/: mcuxCsslAnalysis.h mcuxCsslCPreProcessor.h
  group component/els_pkc/src/comps/mcuxCsslDataIntegrity/inc
    ../../../../../components/els_pkc/src/comps/mcuxCsslDataIntegrity/inc/: mcuxCsslDataIntegrity.h mcuxCsslDataIntegrity_Cfg.h mcuxCsslDataIntegrity_Impl.h mcuxCsslDataIntegrity_None.h
  group component/els_pkc/src/comps/mcuxCsslFlowProtection/inc
    ../../../../../components/els_pkc/src/comps/mcuxCsslFlowProtection/inc/: mcuxCsslFlowProtection.h mcuxCsslFlowProtection_Cfg.h mcuxCsslFlowProtection_FunctionIdentifiers.h mcuxCsslFlowProtection_Impl.h mcuxCsslFlowProtection_SecureCounter_Common.h mcuxCsslFlowProtection_SecureCounter_Local.h
  group component/els_pkc/src/comps/mcuxCsslParamIntegrity/src
    ../../../../../components/els_pkc/src/comps/mcuxCsslParamIntegrity/src/: mcuxCsslParamIntegrity32.c
  group component/els_pkc/src/comps/mcuxCsslParamIntegrity/inc
    ../../../../../components/els_pkc/src/comps/mcuxCsslParamIntegrity/inc/: mcuxCsslParamIntegrity.h
  group component/els_pkc/src/comps/mcuxCsslSecureCounter/inc
    ../../../../../components/els_pkc/src/comps/mcuxCsslSecureCounter/inc/: mcuxCsslSecureCounter.h mcuxCsslSecureCounter_Cfg.h mcuxCsslSecureCounter_Impl.h mcuxCsslSecureCounter_None.h mcuxCsslSecureCounter_SW_Local.h
  group component/els_pkc/src/compiler
    ../../../../../components/els_pkc/src/compiler/: mcuxClToolchain.h
  group component/els_pkc/src/platforms/rw61x
    ../../../../../components/els_pkc/src/platforms/rw61x/: platform_specific_headers.h mcuxClConfig.h
  group component/els_pkc/src/platforms/rw61x/inc
    ../../../../../components/els_pkc/src/platforms/rw61x/inc/: ip_css_constants.h ip_css_design_configuration.h ip_platform.h
  group component/els_pkc/includes
    ../../../../../components/els_pkc/includes/: mcuxClEls_GlitchDetector.h
  group component/els_pkc/includes/platform/rw61x
    ../../../../../components/els_pkc/includes/platform/rw61x/: mcuxClAeadModes_MemoryConsumption.h mcuxClCipherModes_MemoryConsumption.h mcuxClEcc_MemoryConsumption.h mcuxClHashModes_MemoryConsumption.h mcuxClHash_MemoryConsumption.h mcuxClHmac_MemoryConsumption.h mcuxClKey_MemoryConsumption.h mcuxClMacModes_MemoryConsumption.h mcuxClRandomModes_MemoryConsumption.h mcuxClRsa_MemoryConsumption.h mcuxClSession_MemoryConsumption.h
  group video
    ../../../../../components/video/: fsl_video_common.h fsl_video_common.c
    ../../../../../components/video/display/dc/: fsl_dc_fb.h
    ../../../../../components/video/display/: fsl_display.h
    ../../../../../components/video/display/dbi/: fsl_dbi.h fsl_dbi.c
    ../../../../../components/video/display/dbi/lcdic/: fsl_dbi_lcdic_dma.h fsl_dbi_lcdic_dma.c
    ../../../../../components/video/display/dbi/lpc_spi/: fsl_dbi_spi_dma.h fsl_dbi_spi_dma.c
    ../../../../../components/video/display/dc/dbi/: fsl_dc_fb_dbi.h fsl_dc_fb_dbi.c
  group touchpanel
    ../../../../../components/touch/gt911/: fsl_gt911.h fsl_gt911.c
    ../../../../../components/touch/ft6x06/: fsl_ft6x06.h fsl_ft6x06.c
  group lcdc
    ../../../../../components/display/ili9341/: fsl_ili9341.h fsl_ili9341.c
    ../../../../../components/display/st7796s/: fsl_st7796s.h fsl_st7796s.c
  group lvgl
    ../../../../../middleware/lvgl/: lv_conf_template.h lv_version.h lvgl.h lvgl_private.h
  group lvgl/src
    ../../../../../middleware/lvgl/src/: lv_init.c lv_api_map_v8.h lv_api_map_v9_0.h lv_api_map_v9_1.h lv_api_map_v9_2.h lv_api_map_v9_3.h lv_conf_internal.h lv_conf_kconfig.h lv_init.h lvgl.h lvgl_private.h
  group lvgl/src/core
    ../../../../../middleware/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_global.h lv_group.h lv_group_private.h lv_obj.h lv_obj_class.h lv_obj_class_private.h lv_obj_draw.h lv_obj_draw_private.h lv_obj_event.h lv_obj_event_private.h lv_obj_pos.h lv_obj_private.h lv_obj_property.h lv_obj_scroll.h lv_obj_scroll_private.h lv_obj_style.h lv_obj_style_gen.h lv_obj_style_private.h lv_obj_tree.h lv_refr.h lv_refr_private.h
  group lvgl/src/display
    ../../../../../middleware/lvgl/src/display/: lv_display.c lv_display.h lv_display_private.h
  group lvgl/src/draw
    ../../../../../middleware/lvgl/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c lv_draw.h lv_draw_3d.h lv_draw_arc.h lv_draw_buf.h lv_draw_buf_private.h lv_draw_image.h lv_draw_image_private.h lv_draw_label.h lv_draw_label_private.h lv_draw_line.h lv_draw_mask.h lv_draw_mask_private.h lv_draw_private.h lv_draw_rect.h lv_draw_rect_private.h lv_draw_triangle.h lv_draw_triangle_private.h lv_draw_vector.h lv_draw_vector_private.h lv_image_decoder.h lv_image_decoder_private.h lv_image_dsc.h
  group lvgl/src/draw/convert
    ../../../../../middleware/lvgl/src/draw/convert/: lv_draw_buf_convert.c lv_draw_buf_convert.h
  group lvgl/src/draw/convert/helium
    ../../../../../middleware/lvgl/src/draw/convert/helium/: lv_draw_buf_convert_helium.c lv_draw_buf_convert_helium.h
  group lvgl/src/draw/convert/neon
    ../../../../../middleware/lvgl/src/draw/convert/neon/: lv_draw_buf_convert_neon.c lv_draw_buf_convert_neon.h
  group lvgl/src/draw/dma2d
    ../../../../../middleware/lvgl/src/draw/dma2d/: lv_draw_dma2d.c lv_draw_dma2d_fill.c lv_draw_dma2d_img.c lv_draw_dma2d.h lv_draw_dma2d_private.h
  group lvgl/src/draw/espressif/ppa
    ../../../../../middleware/lvgl/src/draw/espressif/ppa/: lv_draw_ppa.c lv_draw_ppa_buf.c lv_draw_ppa_fill.c lv_draw_ppa_img.c lv_draw_ppa.h lv_draw_ppa_private.h
  group lvgl/src/draw/eve
    ../../../../../middleware/lvgl/src/draw/eve/: lv_draw_eve.c lv_draw_eve_arc.c lv_draw_eve_fill.c lv_draw_eve_image.c lv_draw_eve_letter.c lv_draw_eve_line.c lv_draw_eve_ram_g.c lv_draw_eve_triangle.c lv_eve.c lv_draw_eve.h lv_draw_eve_private.h lv_draw_eve_ram_g.h lv_draw_eve_target.h lv_eve.h
  group lvgl/src/draw/nema_gfx
    ../../../../../middleware/lvgl/src/draw/nema_gfx/: lv_draw_nema_gfx.c lv_draw_nema_gfx_arc.c lv_draw_nema_gfx_border.c lv_draw_nema_gfx_fill.c lv_draw_nema_gfx_img.c lv_draw_nema_gfx_label.c lv_draw_nema_gfx_layer.c lv_draw_nema_gfx_line.c lv_draw_nema_gfx_stm32_hal.c lv_draw_nema_gfx_triangle.c lv_draw_nema_gfx_utils.c lv_draw_nema_gfx_vector.c lv_nema_gfx_path.c lv_draw_nema_gfx.h lv_draw_nema_gfx_utils.h lv_nema_gfx_path.h
  group lvgl/src/draw/nxp/g2d
    ../../../../../middleware/lvgl/src/draw/nxp/g2d/: lv_draw_buf_g2d.c lv_draw_g2d.c lv_draw_g2d_fill.c lv_draw_g2d_img.c lv_g2d_buf_map.c lv_g2d_utils.c lv_draw_g2d.h lv_g2d_buf_map.h lv_g2d_utils.h
  group lvgl/src/draw/nxp/pxp
    ../../../../../middleware/lvgl/src/draw/nxp/pxp/: lv_draw_buf_pxp.c lv_draw_pxp.c lv_draw_pxp_fill.c lv_draw_pxp_img.c lv_draw_pxp_layer.c lv_pxp_cfg.c lv_pxp_osa.c lv_pxp_utils.c lv_draw_pxp.h lv_pxp_cfg.h lv_pxp_osa.h lv_pxp_utils.h
  group lvgl/src/draw/opengles
    ../../../../../middleware/lvgl/src/draw/opengles/: lv_draw_opengles.c lv_draw_opengles.h
  group lvgl/src/draw/renesas/dave2d
    ../../../../../middleware/lvgl/src/draw/renesas/dave2d/: lv_draw_dave2d.c lv_draw_dave2d_arc.c lv_draw_dave2d_border.c lv_draw_dave2d_fill.c lv_draw_dave2d_image.c lv_draw_dave2d_label.c lv_draw_dave2d_line.c lv_draw_dave2d_mask_rectangle.c lv_draw_dave2d_triangle.c lv_draw_dave2d_utils.c lv_draw_dave2d.h lv_draw_dave2d_utils.h
  group lvgl/src/draw/sdl
    ../../../../../middleware/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl.h
  group lvgl/src/draw/sw
    ../../../../../middleware/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c lv_draw_sw.h lv_draw_sw_grad.h lv_draw_sw_mask.h lv_draw_sw_mask_private.h lv_draw_sw_private.h lv_draw_sw_utils.h
  group lvgl/src/draw/sw/blend
    ../../../../../middleware/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c lv_draw_sw_blend.h lv_draw_sw_blend_private.h lv_draw_sw_blend_to_al88.h lv_draw_sw_blend_to_argb8888.h lv_draw_sw_blend_to_argb8888_premultiplied.h lv_draw_sw_blend_to_i1.h lv_draw_sw_blend_to_l8.h lv_draw_sw_blend_to_rgb565.h lv_draw_sw_blend_to_rgb565_swapped.h lv_draw_sw_blend_to_rgb888.h
  group lvgl/src/draw/sw/blend/neon
    ../../../../../middleware/lvgl/src/draw/sw/blend/neon/: lv_draw_sw_blend_neon_to_rgb565.c lv_draw_sw_blend_neon_to_rgb888.c lv_blend_neon.h lv_draw_sw_blend_neon_to_rgb565.h lv_draw_sw_blend_neon_to_rgb888.h
  group lvgl/src/draw/sw/blend/arm2d
    ../../../../../middleware/lvgl/src/draw/sw/blend/arm2d/: lv_blend_arm2d.h
  group lvgl/src/draw/sw/blend/helium
    ../../../../../middleware/lvgl/src/draw/sw/blend/helium/: lv_blend_helium.h
  group lvgl/src/draw/sw/arm2d
    ../../../../../middleware/lvgl/src/draw/sw/arm2d/: lv_draw_sw_arm2d.h lv_draw_sw_helium.h
  group lvgl/src/draw/vg_lite
    ../../../../../middleware/lvgl/src/draw/vg_lite/: lv_draw_buf_vg_lite.c lv_draw_vg_lite.c lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_vector.c lv_vg_lite_decoder.c lv_vg_lite_grad.c lv_vg_lite_math.c lv_vg_lite_path.c lv_vg_lite_pending.c lv_vg_lite_stroke.c lv_vg_lite_utils.c lv_draw_vg_lite.h lv_draw_vg_lite_type.h lv_vg_lite_decoder.h lv_vg_lite_grad.h lv_vg_lite_math.h lv_vg_lite_path.h lv_vg_lite_pending.h lv_vg_lite_stroke.h lv_vg_lite_utils.h
  group lvgl/src/drivers
    ../../../../../middleware/lvgl/src/drivers/: lv_drivers.h
  group lvgl/src/drivers/display/drm
    ../../../../../middleware/lvgl/src/drivers/display/drm/: lv_linux_drm.c lv_linux_drm_common.c lv_linux_drm_egl.c lv_linux_drm.h lv_linux_drm_egl_private.h
  group lvgl/src/drivers/display/fb
    ../../../../../middleware/lvgl/src/drivers/display/fb/: lv_linux_fbdev.c lv_linux_fbdev.h
  group lvgl/src/drivers/display/ft81x
    ../../../../../middleware/lvgl/src/drivers/display/ft81x/: lv_ft81x.c lv_ft81x.h lv_ft81x_defines.h
  group lvgl/src/drivers/display/ili9341
    ../../../../../middleware/lvgl/src/drivers/display/ili9341/: lv_ili9341.c lv_ili9341.h
  group lvgl/src/drivers/display/lcd
    ../../../../../middleware/lvgl/src/drivers/display/lcd/: lv_lcd_generic_mipi.c lv_lcd_generic_mipi.h
  group lvgl/src/drivers/display/nv3007
    ../../../../../middleware/lvgl/src/drivers/display/nv3007/: lv_nv3007.c lv_nv3007.h
  group lvgl/src/drivers/display/nxp_elcdif
    ../../../../../middleware/lvgl/src/drivers/display/nxp_elcdif/: lv_nxp_elcdif.c lv_nxp_elcdif.h
  group lvgl/src/drivers/display/renesas_glcdc
    ../../../../../middleware/lvgl/src/drivers/display/renesas_glcdc/: lv_renesas_glcdc.c lv_renesas_glcdc.h
  group lvgl/src/drivers/display/st7735
    ../../../../../middleware/lvgl/src/drivers/display/st7735/: lv_st7735.c lv_st7735.h
  group lvgl/src/drivers/display/st7789
    ../../../../../middleware/lvgl/src/drivers/display/st7789/: lv_st7789.c lv_st7789.h
  group lvgl/src/drivers/display/st7796
    ../../../../../middleware/lvgl/src/drivers/display/st7796/: lv_st7796.c lv_st7796.h
  group lvgl/src/drivers/display/st_ltdc
    ../../../../../middleware/lvgl/src/drivers/display/st_ltdc/: lv_st_ltdc.c lv_st_ltdc.h
  group lvgl/src/drivers/display/lovyan_gfx
    ../../../../../middleware/lvgl/src/drivers/display/lovyan_gfx/: lv_lovyan_gfx.h
  group lvgl/src/drivers/display/tft_espi
    ../../../../../middleware/lvgl/src/drivers/display/tft_espi/: lv_tft_espi.h
  group lvgl/src/drivers/draw/eve
    ../../../../../middleware/lvgl/src/drivers/draw/eve/: lv_draw_eve_display.c lv_draw_eve_display.h lv_draw_eve_display_defines.h
  group lvgl/src/drivers/evdev
    ../../../../../middleware/lvgl/src/drivers/evdev/: lv_evdev.c lv_evdev.h lv_evdev_private.h
  group lvgl/src/drivers/libinput
    ../../../../../middleware/lvgl/src/drivers/libinput/: lv_libinput.c lv_xkb.c lv_libinput.h lv_libinput_private.h lv_xkb.h lv_xkb_private.h
  group lvgl/src/drivers/nuttx
    ../../../../../middleware/lvgl/src/drivers/nuttx/: lv_nuttx_cache.c lv_nuttx_entry.c lv_nuttx_fbdev.c lv_nuttx_image_cache.c lv_nuttx_lcd.c lv_nuttx_libuv.c lv_nuttx_mouse.c lv_nuttx_profiler.c lv_nuttx_touchscreen.c lv_nuttx_cache.h lv_nuttx_entry.h lv_nuttx_fbdev.h lv_nuttx_image_cache.h lv_nuttx_lcd.h lv_nuttx_libuv.h lv_nuttx_mouse.h lv_nuttx_profiler.h lv_nuttx_touchscreen.h
  group lvgl/src/drivers/opengles
    ../../../../../middleware/lvgl/src/drivers/opengles/: lv_opengles_debug.c lv_opengles_driver.c lv_opengles_egl.c lv_opengles_glfw.c lv_opengles_texture.c lv_opengles_debug.h lv_opengles_driver.h lv_opengles_egl.h lv_opengles_egl_private.h lv_opengles_glfw.h lv_opengles_private.h lv_opengles_texture.h lv_opengles_texture_private.h lv_opengles_window.h
  group lvgl/src/drivers/opengles/assets
    ../../../../../middleware/lvgl/src/drivers/opengles/assets/: lv_opengles_shader.c lv_opengles_shader.h
  group lvgl/src/drivers/opengles/glad/src
    ../../../../../middleware/lvgl/src/drivers/opengles/glad/src/: egl.c gles2.c
  group lvgl/src/drivers/opengles/glad/include/EGL
    ../../../../../middleware/lvgl/src/drivers/opengles/glad/include/EGL/: eglplatform.h
  group lvgl/src/drivers/opengles/glad/include/KHR
    ../../../../../middleware/lvgl/src/drivers/opengles/glad/include/KHR/: khrplatform.h
  group lvgl/src/drivers/opengles/glad/include/glad
    ../../../../../middleware/lvgl/src/drivers/opengles/glad/include/glad/: egl.h gles2.h
  group lvgl/src/drivers/opengles/opengl_shader
    ../../../../../middleware/lvgl/src/drivers/opengles/opengl_shader/: lv_opengl_shader_manager.c lv_opengl_shader_program.c lv_opengl_shader_internal.h
  group lvgl/src/drivers/qnx
    ../../../../../middleware/lvgl/src/drivers/qnx/: lv_qnx.c lv_qnx.h
  group lvgl/src/drivers/sdl
    ../../../../../middleware/lvgl/src/drivers/sdl/: lv_sdl_keyboard.c lv_sdl_mouse.c lv_sdl_mousewheel.c lv_sdl_window.c lv_sdl_keyboard.h lv_sdl_mouse.h lv_sdl_mousewheel.h lv_sdl_private.h lv_sdl_window.h
  group lvgl/src/drivers/uefi
    ../../../../../middleware/lvgl/src/drivers/uefi/: lv_uefi_context.c lv_uefi_display.c lv_uefi_indev_keyboard.c lv_uefi_indev_pointer.c lv_uefi_indev_touch.c lv_uefi_private.c lv_uefi.h lv_uefi_context.h lv_uefi_display.h lv_uefi_edk2.h lv_uefi_gnu_efi.h lv_uefi_indev.h lv_uefi_private.h lv_uefi_std_wrapper.h
  group lvgl/src/drivers/wayland
    ../../../../../middleware/lvgl/src/drivers/wayland/: lv_wayland.c lv_wayland_smm.c lv_wl_cache.c lv_wl_dmabuf.c lv_wl_keyboard.c lv_wl_pointer.c lv_wl_pointer_axis.c lv_wl_seat.c lv_wl_shm.c lv_wl_touch.c lv_wl_window.c lv_wl_window_decorations.c lv_wl_xdg_shell.c lv_wayland.h lv_wayland_private.h lv_wayland_smm.h lv_wl_keyboard.h lv_wl_pointer.h lv_wl_pointer_axis.h lv_wl_touch.h lv_wl_window.h
  group lvgl/src/drivers/windows
    ../../../../../middleware/lvgl/src/drivers/windows/: lv_windows_context.c lv_windows_display.c lv_windows_input.c lv_windows_context.h lv_windows_display.h lv_windows_input.h lv_windows_input_private.h
  group lvgl/src/drivers/x11
    ../../../../../middleware/lvgl/src/drivers/x11/: lv_x11_display.c lv_x11_input.c lv_x11.h
  group lvgl/src/font
    ../../../../../middleware/lvgl/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c lv_binfont_loader.h lv_font.h lv_font_fmt_txt.h lv_font_fmt_txt_private.h lv_symbol_def.h
  group lvgl/src/indev
    ../../../../../middleware/lvgl/src/indev/: lv_indev.c lv_indev_gesture.c lv_indev_scroll.c lv_indev.h lv_indev_gesture.h lv_indev_gesture_private.h lv_indev_private.h lv_indev_scroll.h
  group lvgl/src/layouts
    ../../../../../middleware/lvgl/src/layouts/: lv_layout.c lv_layout.h lv_layout_private.h
  group lvgl/src/layouts/flex
    ../../../../../middleware/lvgl/src/layouts/flex/: lv_flex.c lv_flex.h
  group lvgl/src/layouts/grid
    ../../../../../middleware/lvgl/src/layouts/grid/: lv_grid.c lv_grid.h
  group lvgl/src/libs/FT800-FT813
    ../../../../../middleware/lvgl/src/libs/FT800-FT813/: EVE_commands.c EVE_supplemental.c EVE.h EVE_commands.h EVE_config.h EVE_suppplemental.h EVE_target.h
  group lvgl/src/libs/barcode
    ../../../../../middleware/lvgl/src/libs/barcode/: code128.c lv_barcode.c code128.h lv_barcode.h lv_barcode_private.h
  group lvgl/src/libs/bin_decoder
    ../../../../../middleware/lvgl/src/libs/bin_decoder/: lv_bin_decoder.c lv_bin_decoder.h
  group lvgl/src/libs/bmp
    ../../../../../middleware/lvgl/src/libs/bmp/: lv_bmp.c lv_bmp.h
  group lvgl/src/libs/expat
    ../../../../../middleware/lvgl/src/libs/expat/: xmlparse.c xmlrole.c xmltok.c xmltok_impl.c xmltok_ns.c ascii.h asciitab.h expat.h expat_config.h expat_external.h iasciitab.h internal.h latin1tab.h nametab.h siphash.h utf8tab.h winconfig.h xmlrole.h xmltok.h xmltok_impl.h
  group lvgl/src/libs/ffmpeg
    ../../../../../middleware/lvgl/src/libs/ffmpeg/: lv_ffmpeg.c lv_ffmpeg.h lv_ffmpeg_private.h
  group lvgl/src/libs/freetype
    ../../../../../middleware/lvgl/src/libs/freetype/: lv_freetype.c lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_ftsystem.c ftmodule.h ftoption.h lv_freetype.h lv_freetype_private.h
  group lvgl/src/libs/frogfs/src
    ../../../../../middleware/lvgl/src/libs/frogfs/src/: decomp_raw.c frogfs.c frogfs_format.h frogfs_priv.h
  group lvgl/src/libs/frogfs/include/frogfs
    ../../../../../middleware/lvgl/src/libs/frogfs/include/frogfs/: frogfs.h frogfs_types.h
  group lvgl/src/libs/fsdrv
    ../../../../../middleware/lvgl/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_frogfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_uefi.c lv_fs_win32.c lv_fsdrv.h
  group lvgl/src/libs/gif
    ../../../../../middleware/lvgl/src/libs/gif/: lv_gif.c lv_gif.h
  group lvgl/src/libs/gif/AnimatedGIF/src
    ../../../../../middleware/lvgl/src/libs/gif/AnimatedGIF/src/: gif.c AnimatedGIF.h
  group lvgl/src/libs/gltf/gltf_view
    ../../../../../middleware/lvgl/src/libs/gltf/gltf_view/: lv_gltf.h lv_gltf_view_internal.h
  group lvgl/src/libs/gltf/gltf_view/assets
    ../../../../../middleware/lvgl/src/libs/gltf/gltf_view/assets/: chromatic.c lv_gltf_view_shader.c lv_gltf_view_shader.h
  group lvgl/src/libs/gltf/gltf_view/ibl
    ../../../../../middleware/lvgl/src/libs/gltf/gltf_view/ibl/: lv_gltf_ibl_sampler.c lv_gltf_ibl_sampler.h
  group lvgl/src/libs/gltf/gltf_data
    ../../../../../middleware/lvgl/src/libs/gltf/gltf_data/: lv_gltf_bind.h lv_gltf_data_internal.h lv_gltf_model.h
  group lvgl/src/libs/gltf/stb_image
    ../../../../../middleware/lvgl/src/libs/gltf/stb_image/: stb_image.h
  group lvgl/src/libs/gstreamer
    ../../../../../middleware/lvgl/src/libs/gstreamer/: lv_gstreamer.c lv_gstreamer.h lv_gstreamer_internal.h
  group lvgl/src/libs/libjpeg_turbo
    ../../../../../middleware/lvgl/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c lv_libjpeg_turbo.h
  group lvgl/src/libs/libpng
    ../../../../../middleware/lvgl/src/libs/libpng/: lv_libpng.c lv_libpng.h
  group lvgl/src/libs/lodepng
    ../../../../../middleware/lvgl/src/libs/lodepng/: lodepng.c lv_lodepng.c lodepng.h lv_lodepng.h
  group lvgl/src/libs/lz4
    ../../../../../middleware/lvgl/src/libs/lz4/: lz4.c lz4.h
  group lvgl/src/libs/qrcode
    ../../../../../middleware/lvgl/src/libs/qrcode/: lv_qrcode.c qrcodegen.c lv_qrcode.h lv_qrcode_private.h qrcodegen.h
  group lvgl/src/libs/rle
    ../../../../../middleware/lvgl/src/libs/rle/: lv_rle.c lv_rle.h
  group lvgl/src/libs/rlottie
    ../../../../../middleware/lvgl/src/libs/rlottie/: lv_rlottie.c lv_rlottie.h lv_rlottie_private.h
  group lvgl/src/libs/svg
    ../../../../../middleware/lvgl/src/libs/svg/: lv_svg.c lv_svg_decoder.c lv_svg_parser.c lv_svg_render.c lv_svg_token.c lv_svg.h lv_svg_decoder.h lv_svg_parser.h lv_svg_render.h lv_svg_token.h
  group lvgl/src/libs/tiny_ttf
    ../../../../../middleware/lvgl/src/libs/tiny_ttf/: lv_tiny_ttf.c lv_tiny_ttf.h stb_rect_pack.h stb_truetype_htcw.h
  group lvgl/src/libs/tjpgd
    ../../../../../middleware/lvgl/src/libs/tjpgd/: lv_tjpgd.c tjpgd.c lv_tjpgd.h tjpgd.h tjpgdcnf.h
  group lvgl/src/libs/vg_lite_driver/VGLite
    ../../../../../middleware/lvgl/src/libs/vg_lite_driver/VGLite/: vg_lite.c vg_lite_image.c vg_lite_matrix.c vg_lite_path.c vg_lite_stroke.c vg_lite_context.h vg_lite_options.h
  group lvgl/src/libs/vg_lite_driver/VGLite/Series/gc255/0x40A
    ../../../../../middleware/lvgl/src/libs/vg_lite_driver/VGLite/Series/gc255/0x40A/: vg_lite_options.h
  group lvgl/src/libs/vg_lite_driver/VGLite/Series/gc355/0x0_1215
    ../../../../../middleware/lvgl/src/libs/vg_lite_driver/VGLite/Series/gc355/0x0_1215/: vg_lite_options.h
  group lvgl/src/libs/vg_lite_driver/VGLite/Series/gc355/0x0_1216
    ../../../../../middleware/lvgl/src/libs/vg_lite_driver/VGLite/Series/gc355/0x0_1216/: vg_lite_options.h
  group lvgl/src/libs/vg_lite_driver/VGLite/Series/gc555/0x423
    ../../../../../middleware/lvgl/src/libs/vg_lite_driver/VGLite/Series/gc555/0x423/: vg_lite_options.h
  group lvgl/src/libs/vg_lite_driver/VGLite/Series/gc555/0x423_ECO
    ../../../../../middleware/lvgl/src/libs/vg_lite_driver/VGLite/Series/gc555/0x423_ECO/: vg_lite_options.h
  group lvgl/src/libs/vg_lite_driver/VGLiteKernel
    ../../../../../middleware/lvgl/src/libs/vg_lite_driver/VGLiteKernel/: vg_lite_kernel.c vg_lite_debug.h vg_lite_hal.h vg_lite_hw.h vg_lite_kernel.h vg_lite_option.h vg_lite_type.h
  group lvgl/src/libs/vg_lite_driver/lv_vg_lite_hal
    ../../../../../middleware/lvgl/src/libs/vg_lite_driver/lv_vg_lite_hal/: lv_vg_lite_hal.c vg_lite_os.c vg_lite_platform.h
  group lvgl/src/libs/vg_lite_driver/inc
    ../../../../../middleware/lvgl/src/libs/vg_lite_driver/inc/: vg_lite.h
  group lvgl/src/libs/thorvg
    ../../../../../middleware/lvgl/src/libs/thorvg/: config.h thorvg.h thorvg_capi.h thorvg_lottie.h tvgAnimation.h tvgArray.h tvgBinaryDesc.h tvgCanvas.h tvgCommon.h tvgCompressor.h tvgFill.h tvgFrameModule.h tvgInlist.h tvgIteratorAccessor.h tvgLoadModule.h tvgLoader.h tvgLock.h tvgLottieBuilder.h tvgLottieCommon.h tvgLottieExpressions.h tvgLottieInterpolator.h tvgLottieLoader.h tvgLottieModel.h tvgLottieModifier.h tvgLottieParser.h tvgLottieParserHandler.h tvgLottieProperty.h tvgLottieRenderPooler.h tvgMath.h tvgPaint.h tvgPicture.h tvgRawLoader.h tvgRender.h tvgSaveModule.h tvgScene.h tvgShape.h tvgStr.h tvgSvgCssStyle.h tvgSvgLoader.h tvgSvgLoaderCommon.h tvgSvgPath.h tvgSvgSceneBuilder.h tvgSvgUtil.h tvgSwCommon.h tvgSwRasterAvx.h tvgSwRasterC.h tvgSwRasterNeon.h tvgSwRasterTexmap.h tvgSwRenderer.h tvgTaskScheduler.h tvgText.h tvgXmlParser.h
  group lvgl/src/libs/thorvg/rapidjson
    ../../../../../middleware/lvgl/src/libs/thorvg/rapidjson/: allocators.h cursorstreamwrapper.h document.h encodedstream.h encodings.h filereadstream.h filewritestream.h fwd.h istreamwrapper.h memorybuffer.h memorystream.h ostreamwrapper.h pointer.h prettywriter.h rapidjson.h reader.h schema.h stream.h stringbuffer.h uri.h writer.h
  group lvgl/src/libs/thorvg/rapidjson/error
    ../../../../../middleware/lvgl/src/libs/thorvg/rapidjson/error/: en.h error.h
  group lvgl/src/libs/thorvg/rapidjson/internal
    ../../../../../middleware/lvgl/src/libs/thorvg/rapidjson/internal/: biginteger.h clzll.h diyfp.h dtoa.h ieee754.h itoa.h meta.h pow10.h regex.h stack.h strfunc.h strtod.h swap.h
  group lvgl/src/libs/thorvg/rapidjson/msinttypes
    ../../../../../middleware/lvgl/src/libs/thorvg/rapidjson/msinttypes/: inttypes.h stdint.h
  group lvgl/src/misc
    ../../../../../middleware/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin.c lv_profiler_builtin_posix.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c lv_anim.h lv_anim_private.h lv_anim_timeline.h lv_anim_timeline_private.h lv_area.h lv_area_private.h lv_array.h lv_assert.h lv_async.h lv_bidi.h lv_bidi_private.h lv_circle_buf.h lv_color.h lv_color_op.h lv_color_op_private.h lv_event.h lv_event_private.h lv_fs.h lv_fs_private.h lv_grad.h lv_iter.h lv_ll.h lv_log.h lv_lru.h lv_math.h lv_matrix.h lv_palette.h lv_profiler.h lv_profiler_builtin.h lv_profiler_builtin_private.h lv_rb.h lv_rb_private.h lv_style.h lv_style_gen.h lv_style_private.h lv_templ.h lv_text.h lv_text_ap.h lv_text_private.h lv_timer.h lv_timer_private.h lv_tree.h lv_types.h lv_utils.h
  group lvgl/src/misc/cache
    ../../../../../middleware/lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c lv_cache.h lv_cache_entry.h lv_cache_entry_private.h lv_cache_private.h
  group lvgl/src/misc/cache/class
    ../../../../../middleware/lvgl/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c lv_cache_class.h lv_cache_lru_ll.h lv_cache_lru_rb.h lv_cache_sc_da.h
  group lvgl/src/misc/cache/instance
    ../../../../../middleware/lvgl/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c lv_cache_instance.h lv_image_cache.h lv_image_header_cache.h
  group lvgl/src/osal
    ../../../../../middleware/lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c lv_cmsis_rtos2.h lv_freertos.h lv_linux.h lv_mqx.h lv_os.h lv_os_none.h lv_os_private.h lv_pthread.h lv_rtthread.h lv_sdl2.h lv_windows.h
  group lvgl/src/others/file_explorer
    ../../../../../middleware/lvgl/src/others/file_explorer/: lv_file_explorer.c lv_file_explorer.h lv_file_explorer_private.h
  group lvgl/src/others/font_manager
    ../../../../../middleware/lvgl/src/others/font_manager/: lv_font_manager.c lv_font_manager_recycle.c lv_font_manager.h lv_font_manager_recycle.h
  group lvgl/src/others/fragment
    ../../../../../middleware/lvgl/src/others/fragment/: lv_fragment.c lv_fragment_manager.c lv_fragment.h lv_fragment_private.h
  group lvgl/src/others/gridnav
    ../../../../../middleware/lvgl/src/others/gridnav/: lv_gridnav.c lv_gridnav.h
  group lvgl/src/others/ime
    ../../../../../middleware/lvgl/src/others/ime/: lv_ime_pinyin.c lv_ime_pinyin.h lv_ime_pinyin_private.h
  group lvgl/src/others/imgfont
    ../../../../../middleware/lvgl/src/others/imgfont/: lv_imgfont.c lv_imgfont.h
  group lvgl/src/others/monkey
    ../../../../../middleware/lvgl/src/others/monkey/: lv_monkey.c lv_monkey.h lv_monkey_private.h
  group lvgl/src/others/observer
    ../../../../../middleware/lvgl/src/others/observer/: lv_observer.c lv_observer.h lv_observer_private.h
  group lvgl/src/others/snapshot
    ../../../../../middleware/lvgl/src/others/snapshot/: lv_snapshot.c lv_snapshot.h
  group lvgl/src/others/sysmon
    ../../../../../middleware/lvgl/src/others/sysmon/: lv_sysmon.c lv_sysmon.h lv_sysmon_private.h
  group lvgl/src/others/test
    ../../../../../middleware/lvgl/src/others/test/: lv_test_display.c lv_test_helpers.c lv_test_indev.c lv_test_indev_gesture.c lv_test_screenshot_compare.c lv_test.h lv_test_display.h lv_test_helpers.h lv_test_indev.h lv_test_indev_gesture.h lv_test_private.h lv_test_screenshot_compare.h
  group lvgl/src/others/translation
    ../../../../../middleware/lvgl/src/others/translation/: lv_translation.c lv_translation.h lv_translation_private.h
  group lvgl/src/others/vg_lite_tvg
    ../../../../../middleware/lvgl/src/others/vg_lite_tvg/: vg_lite_matrix.c vg_lite.h
  group lvgl/src/others/xml
    ../../../../../middleware/lvgl/src/others/xml/: lv_xml.c lv_xml_base_types.c lv_xml_component.c lv_xml_load.c lv_xml_parser.c lv_xml_style.c lv_xml_test.c lv_xml_translation.c lv_xml_update.c lv_xml_utils.c lv_xml_widget.c lv_xml.h lv_xml_base_types.h lv_xml_component.h lv_xml_component_private.h lv_xml_load.h lv_xml_load_private.h lv_xml_parser.h lv_xml_private.h lv_xml_style.h lv_xml_test.h lv_xml_translation.h lv_xml_update.h lv_xml_utils.h lv_xml_widget.h
  group lvgl/src/others/xml/parsers
    ../../../../../middleware/lvgl/src/others/xml/parsers/: lv_xml_arc_parser.c lv_xml_bar_parser.c lv_xml_button_parser.c lv_xml_buttonmatrix_parser.c lv_xml_calendar_parser.c lv_xml_canvas_parser.c lv_xml_chart_parser.c lv_xml_checkbox_parser.c lv_xml_dropdown_parser.c lv_xml_image_parser.c lv_xml_keyboard_parser.c lv_xml_label_parser.c lv_xml_obj_parser.c lv_xml_qrcode_parser.c lv_xml_roller_parser.c lv_xml_scale_parser.c lv_xml_slider_parser.c lv_xml_spangroup_parser.c lv_xml_spinbox_parser.c lv_xml_switch_parser.c lv_xml_table_parser.c lv_xml_tabview_parser.c lv_xml_textarea_parser.c lv_xml_arc_parser.h lv_xml_bar_parser.h lv_xml_button_parser.h lv_xml_buttonmatrix_parser.h lv_xml_calendar_parser.h lv_xml_canvas_parser.h lv_xml_chart_parser.h lv_xml_checkbox_parser.h lv_xml_dropdown_parser.h lv_xml_image_parser.h lv_xml_keyboard_parser.h lv_xml_label_parser.h lv_xml_obj_parser.h lv_xml_qrcode_parser.h lv_xml_roller_parser.h lv_xml_scale_parser.h lv_xml_slider_parser.h lv_xml_spangroup_parser.h lv_xml_spinbox_parser.h lv_xml_switch_parser.h lv_xml_table_parser.h lv_xml_tabview_parser.h lv_xml_textarea_parser.h
  group lvgl/src/stdlib
    ../../../../../middleware/lvgl/src/stdlib/: lv_mem.c lv_mem.h lv_mem_private.h lv_sprintf.h lv_string.h
  group lvgl/src/stdlib/builtin
    ../../../../../middleware/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c lv_tlsf.h lv_tlsf_private.h
  group lvgl/src/stdlib/clib
    ../../../../../middleware/lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
  group lvgl/src/stdlib/micropython
    ../../../../../middleware/lvgl/src/stdlib/micropython/: lv_mem_core_micropython.c
  group lvgl/src/stdlib/rtthread
    ../../../../../middleware/lvgl/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
  group lvgl/src/stdlib/uefi
    ../../../../../middleware/lvgl/src/stdlib/uefi/: lv_mem_core_uefi.c
  group lvgl/src/themes
    ../../../../../middleware/lvgl/src/themes/: lv_theme.c lv_theme.h lv_theme_private.h
  group lvgl/src/themes/default
    ../../../../../middleware/lvgl/src/themes/default/: lv_theme_default.c lv_theme_default.h
  group lvgl/src/themes/mono
    ../../../../../middleware/lvgl/src/themes/mono/: lv_theme_mono.c lv_theme_mono.h
  group lvgl/src/themes/simple
    ../../../../../middleware/lvgl/src/themes/simple/: lv_theme_simple.c lv_theme_simple.h
  group lvgl/src/tick
    ../../../../../middleware/lvgl/src/tick/: lv_tick.c lv_tick.h lv_tick_private.h
  group lvgl/src/widgets/3dtexture
    ../../../../../middleware/lvgl/src/widgets/3dtexture/: lv_3dtexture.c lv_3dtexture.h lv_3dtexture_private.h
  group lvgl/src/widgets/animimage
    ../../../../../middleware/lvgl/src/widgets/animimage/: lv_animimage.c lv_animimage.h lv_animimage_private.h
  group lvgl/src/widgets/arc
    ../../../../../middleware/lvgl/src/widgets/arc/: lv_arc.c lv_arc.h lv_arc_private.h
  group lvgl/src/widgets/arclabel
    ../../../../../middleware/lvgl/src/widgets/arclabel/: lv_arclabel.c lv_arclabel.h lv_arclabel_private.h
  group lvgl/src/widgets/bar
    ../../../../../middleware/lvgl/src/widgets/bar/: lv_bar.c lv_bar.h lv_bar_private.h
  group lvgl/src/widgets/button
    ../../../../../middleware/lvgl/src/widgets/button/: lv_button.c lv_button.h lv_button_private.h
  group lvgl/src/widgets/buttonmatrix
    ../../../../../middleware/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c lv_buttonmatrix.h lv_buttonmatrix_private.h
  group lvgl/src/widgets/calendar
    ../../../../../middleware/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c lv_calendar.h lv_calendar_chinese.h lv_calendar_header_arrow.h lv_calendar_header_dropdown.h lv_calendar_private.h
  group lvgl/src/widgets/canvas
    ../../../../../middleware/lvgl/src/widgets/canvas/: lv_canvas.c lv_canvas.h lv_canvas_private.h
  group lvgl/src/widgets/chart
    ../../../../../middleware/lvgl/src/widgets/chart/: lv_chart.c lv_chart.h lv_chart_private.h
  group lvgl/src/widgets/checkbox
    ../../../../../middleware/lvgl/src/widgets/checkbox/: lv_checkbox.c lv_checkbox.h lv_checkbox_private.h
  group lvgl/src/widgets/dropdown
    ../../../../../middleware/lvgl/src/widgets/dropdown/: lv_dropdown.c lv_dropdown.h lv_dropdown_private.h
  group lvgl/src/widgets/image
    ../../../../../middleware/lvgl/src/widgets/image/: lv_image.c lv_image.h lv_image_private.h
  group lvgl/src/widgets/imagebutton
    ../../../../../middleware/lvgl/src/widgets/imagebutton/: lv_imagebutton.c lv_imagebutton.h lv_imagebutton_private.h
  group lvgl/src/widgets/keyboard
    ../../../../../middleware/lvgl/src/widgets/keyboard/: lv_keyboard.c lv_keyboard.h lv_keyboard_private.h
  group lvgl/src/widgets/label
    ../../../../../middleware/lvgl/src/widgets/label/: lv_label.c lv_label.h lv_label_private.h
  group lvgl/src/widgets/led
    ../../../../../middleware/lvgl/src/widgets/led/: lv_led.c lv_led.h lv_led_private.h
  group lvgl/src/widgets/line
    ../../../../../middleware/lvgl/src/widgets/line/: lv_line.c lv_line.h lv_line_private.h
  group lvgl/src/widgets/list
    ../../../../../middleware/lvgl/src/widgets/list/: lv_list.c lv_list.h
  group lvgl/src/widgets/lottie
    ../../../../../middleware/lvgl/src/widgets/lottie/: lv_lottie.c lv_lottie.h lv_lottie_private.h
  group lvgl/src/widgets/menu
    ../../../../../middleware/lvgl/src/widgets/menu/: lv_menu.c lv_menu.h lv_menu_private.h
  group lvgl/src/widgets/msgbox
    ../../../../../middleware/lvgl/src/widgets/msgbox/: lv_msgbox.c lv_msgbox.h lv_msgbox_private.h
  group lvgl/src/widgets/objx_templ
    ../../../../../middleware/lvgl/src/widgets/objx_templ/: lv_objx_templ.c lv_objx_templ.h
  group lvgl/src/widgets/property
    ../../../../../middleware/lvgl/src/widgets/property/: lv_animimage_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_obj_properties.c lv_roller_properties.c lv_slider_properties.c lv_style_properties.c lv_textarea_properties.c lv_obj_property_names.h lv_style_properties.h
  group lvgl/src/widgets/roller
    ../../../../../middleware/lvgl/src/widgets/roller/: lv_roller.c lv_roller.h lv_roller_private.h
  group lvgl/src/widgets/scale
    ../../../../../middleware/lvgl/src/widgets/scale/: lv_scale.c lv_scale.h lv_scale_private.h
  group lvgl/src/widgets/slider
    ../../../../../middleware/lvgl/src/widgets/slider/: lv_slider.c lv_slider.h lv_slider_private.h
  group lvgl/src/widgets/span
    ../../../../../middleware/lvgl/src/widgets/span/: lv_span.c lv_span.h lv_span_private.h
  group lvgl/src/widgets/spinbox
    ../../../../../middleware/lvgl/src/widgets/spinbox/: lv_spinbox.c lv_spinbox.h lv_spinbox_private.h
  group lvgl/src/widgets/spinner
    ../../../../../middleware/lvgl/src/widgets/spinner/: lv_spinner.c lv_spinner.h
  group lvgl/src/widgets/switch
    ../../../../../middleware/lvgl/src/widgets/switch/: lv_switch.c lv_switch.h lv_switch_private.h
  group lvgl/src/widgets/table
    ../../../../../middleware/lvgl/src/widgets/table/: lv_table.c lv_table.h lv_table_private.h
  group lvgl/src/widgets/tabview
    ../../../../../middleware/lvgl/src/widgets/tabview/: lv_tabview.c lv_tabview.h lv_tabview_private.h
  group lvgl/src/widgets/textarea
    ../../../../../middleware/lvgl/src/widgets/textarea/: lv_textarea.c lv_textarea.h lv_textarea_private.h
  group lvgl/src/widgets/tileview
    ../../../../../middleware/lvgl/src/widgets/tileview/: lv_tileview.c lv_tileview.h lv_tileview_private.h
  group lvgl/src/widgets/win
    ../../../../../middleware/lvgl/src/widgets/win/: lv_win.c lv_win.h lv_win_private.h
  group freertos/freertos-kernel-upstream
    ../../../../../rtos/freertos/freertos-kernel-upstream/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel-upstream/include
    ../../../../../rtos/freertos/freertos-kernel-upstream/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h
  group freertos/freertos-kernel-upstream/portable
    ../../../../../rtos/freertos/freertos-kernel-upstream/portable/: readme.txt
  group freertos/freertos-kernel-upstream/portable/MemMang
    ../../../../../rtos/freertos/freertos-kernel-upstream/portable/MemMang/: ReadMe.url
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../rtos/freertos/freertos-kernel-upstream/portable/MemMang/: heap_4.c
  group freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure
    ../../../../../rtos/freertos/freertos-kernel-upstream/portable/IAR/ARM_CM33_NTZ/non_secure/: mpu_wrappers_v2_asm.S port.c portasm.h portasm.s portmacro.h portmacrocommon.h
  group freertos/freertos-kernel/template
    ../../../../../rtos/freertos/freertos-kernel/template/: FreeRTOSConfig.h
  group freertos/freertos-kernel/include
    ../../../../../rtos/freertos/freertos-kernel/include/: freertos_tasks_c_additions.h
  group doc
    ../: readme.md lvgl_examples_readme.md examples_shared_readme.md
